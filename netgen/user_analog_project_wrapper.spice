* NGSPICE file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt sky130_fd_pr__nfet_g5v0d10v5$1$3 a_700_n50# a_n892_n272# a_n758_n50# a_n700_n138#
X0 a_700_n50# a_n700_n138# a_n758_n50# a_n892_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=7e+06u
.ends

.subckt w50_l700_nmos$2 sky130_fd_pr__nfet_g5v0d10v5$1$3_0/a_700_n50# sky130_fd_pr__nfet_g5v0d10v5$1$3_0/a_n758_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$1$3_0/a_n700_n138# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$1$3_0 sky130_fd_pr__nfet_g5v0d10v5$1$3_0/a_700_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$1$3_0/a_n758_n50# sky130_fd_pr__nfet_g5v0d10v5$1$3_0/a_n700_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$1$3
.ends

.subckt x1T1R_w50_l700_nmos$1 B D DIODE RRAM$1$1_0/VSUBS
Xw50_l700_nmos$2_0 RRAM$1$1_0/TE m1_n18719_n21593# w_5419_n25463# RRAM$1$1_0/VSUBS
+ w50_l700_nmos$2
D0 RRAM$1$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$2$1 a_n500_n138# a_500_n50# a_n692_n272# a_n558_n50#
X0 a_500_n50# a_n500_n138# a_n558_n50# a_n692_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_nmos$2 sky130_fd_pr__nfet_g5v0d10v5$2$1_0/a_n558_n50# sky130_fd_pr__nfet_g5v0d10v5$2$1_0/a_n500_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$2$1_0/a_500_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$2$1_0 sky130_fd_pr__nfet_g5v0d10v5$2$1_0/a_n500_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$2$1_0/a_500_n50# VSUBS sky130_fd_pr__nfet_g5v0d10v5$2$1_0/a_n558_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$2$1
.ends

.subckt x1T1R_w50_l500_nmos$1 B D DIODE RRAM$2$1_0/VSUBS
Xw50_l500_nmos$2_0 m1_n18719_n21695# w_5419_n25463# RRAM$2$1_0/TE RRAM$2$1_0/VSUBS
+ w50_l500_nmos$2
D0 RRAM$2$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$3$1 a_1000_n50# w_n1258_n347# a_n1000_n147# a_n1058_n50#
X0 a_1000_n50# a_n1000_n147# a_n1058_n50# w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_pmos$2 sky130_fd_pr__pfet_g5v0d10v5$3$1_0/a_n1058_n50# sky130_fd_pr__pfet_g5v0d10v5$3$1_0/a_1000_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$3$1_0/w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5$3$1_0/a_n1000_n147#
Xsky130_fd_pr__pfet_g5v0d10v5$3$1_0 sky130_fd_pr__pfet_g5v0d10v5$3$1_0/a_1000_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$3$1_0/w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5$3$1_0/a_n1000_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$3$1_0/a_n1058_n50# sky130_fd_pr__pfet_g5v0d10v5$3$1
.ends

.subckt x1T1R_w50_l1000_pmos$1 B D DIODE
Xw50_l1000_pmos$2_0 RRAM$10$1_0/TE D li_n19119_n22791# w_5419_n25463# w50_l1000_pmos$2
D0 RRAM$10$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$2$1 a_700_n50# a_n700_n147# a_n758_n50# w_n958_n347#
X0 a_700_n50# a_n700_n147# a_n758_n50# w_n958_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=7e+06u
.ends

.subckt w50_l700_pmos$2 sky130_fd_pr__pfet_g5v0d10v5$2$1_0/w_n958_n347# sky130_fd_pr__pfet_g5v0d10v5$2$1_0/a_700_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$2$1_0/a_n758_n50# sky130_fd_pr__pfet_g5v0d10v5$2$1_0/a_n700_n147#
Xsky130_fd_pr__pfet_g5v0d10v5$2$1_0 sky130_fd_pr__pfet_g5v0d10v5$2$1_0/a_700_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$2$1_0/a_n700_n147# sky130_fd_pr__pfet_g5v0d10v5$2$1_0/a_n758_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$2$1_0/w_n958_n347# sky130_fd_pr__pfet_g5v0d10v5$2$1
.ends

.subckt x1T1R_w50_l700_pmos$1 B D DIODE
Xw50_l700_pmos$2_0 li_n19119_n22791# D RRAM$9$1_0/TE w_5419_n25463# w50_l700_pmos$2
D0 RRAM$9$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$3$1 a_n492_n272# a_n358_n50# a_300_n50# a_n300_n138#
X0 a_300_n50# a_n300_n138# a_n358_n50# a_n492_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=3e+06u
.ends

.subckt w50_l300_nmos$2 sky130_fd_pr__nfet_g5v0d10v5$3$1_0/a_300_n50# sky130_fd_pr__nfet_g5v0d10v5$3$1_0/a_n358_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$3$1_0/a_n300_n138# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$3$1_0 VSUBS sky130_fd_pr__nfet_g5v0d10v5$3$1_0/a_n358_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$3$1_0/a_300_n50# sky130_fd_pr__nfet_g5v0d10v5$3$1_0/a_n300_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$3$1
.ends

.subckt x1T1R_w50_l300_nmos$1 B D DIODE RRAM$3$1_0/VSUBS
Xw50_l300_nmos$2_0 RRAM$3$1_0/TE m1_n18719_n21895# w_5419_n25463# RRAM$3$1_0/VSUBS
+ w50_l300_nmos$2
D0 RRAM$3$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$1$2$1 a_n1000_n138# a_n1192_n272# a_n1058_n50#
X0 a_1000_n50# a_n1000_n138# a_n1058_n50# a_n1192_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_nmos$1$1 sky130_fd_pr__nfet_g5v0d10v5$1$2$1_0/a_n1000_n138# sky130_fd_pr__nfet_g5v0d10v5$1$2$1_0/a_n1058_n50#
+ VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$1$2$1_0 sky130_fd_pr__nfet_g5v0d10v5$1$2$1_0/a_n1000_n138#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$1$2$1_0/a_n1058_n50# sky130_fd_pr__nfet_g5v0d10v5$1$2$1
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1$3$1 a_1000_n50# w_n1258_n347# a_n1000_n147#
+ a_n1058_n50#
X0 a_1000_n50# a_n1000_n147# a_n1058_n50# w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_pmos$1$1 sky130_fd_pr__pfet_g5v0d10v5$1$3$1_0/w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5$1$3$1_0/a_1000_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$3$1_0/a_n1000_n147# sky130_fd_pr__pfet_g5v0d10v5$1$3$1_0/a_n1058_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$1$3$1_0 sky130_fd_pr__pfet_g5v0d10v5$1$3$1_0/a_1000_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$3$1_0/w_n1258_n347# sky130_fd_pr__pfet_g5v0d10v5$1$3$1_0/a_n1000_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$3$1_0/a_n1058_n50# sky130_fd_pr__pfet_g5v0d10v5$1$3$1
.ends

.subckt x2T1R_w50_l1000$1 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$5$1_0/VSUBS
Xw50_l1000_nmos$1$1_0 w_5419_n25463# m1_n18719_n20953# RRAM$4$5$1_0/VSUBS w50_l1000_nmos$1$1
Xw50_l1000_pmos$1$1_0 li_n19119_n18569# m1_n18719_n20953# w_41419_n25463# RRAM$4$5$1_0/TE
+ w50_l1000_pmos$1$1
D0 RRAM$4$5$1_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$5$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1$1$1 w_n758_n347# a_500_n50# a_n500_n147# a_n558_n50#
X0 a_500_n50# a_n500_n147# a_n558_n50# w_n758_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_pmos$2 sky130_fd_pr__pfet_g5v0d10v5$1$1$1_0/a_n500_n147# sky130_fd_pr__pfet_g5v0d10v5$1$1$1_0/a_500_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$1$1_0/w_n758_n347# sky130_fd_pr__pfet_g5v0d10v5$1$1$1_0/a_n558_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$1$1$1_0 sky130_fd_pr__pfet_g5v0d10v5$1$1$1_0/w_n758_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$1$1$1_0/a_500_n50# sky130_fd_pr__pfet_g5v0d10v5$1$1$1_0/a_n500_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$1$1_0/a_n558_n50# sky130_fd_pr__pfet_g5v0d10v5$1$1$1
.ends

.subckt x1T1R_w50_l500_pmos$1 B D DIODE
Xw50_l500_pmos$2_0 w_5419_n25463# D li_n19119_n22791# RRAM$8$1_0/TE w50_l500_pmos$2
D0 RRAM$8$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$4$2 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272#
X0 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_nmos$2 sky130_fd_pr__nfet_g5v0d10v5$4$2_0/a_100_n50# sky130_fd_pr__nfet_g5v0d10v5$4$2_0/a_n100_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$4$2_0/a_n158_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$4$2_0 sky130_fd_pr__nfet_g5v0d10v5$4$2_0/a_100_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$4$2_0/a_n100_n138# sky130_fd_pr__nfet_g5v0d10v5$4$2_0/a_n158_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$4$2
.ends

.subckt x1T1R_w50_l100_nmos$1 B D DIODE RRAM$4$6_0/VSUBS
Xw50_l100_nmos$2_0 RRAM$4$6_0/TE w_5419_n25463# m1_n18719_n22101# RRAM$4$6_0/VSUBS
+ w50_l100_nmos$2
D0 RRAM$4$6_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$6$1 a_700_n50# a_n892_n272# a_n758_n50# a_n700_n138#
X0 a_700_n50# a_n700_n138# a_n758_n50# a_n892_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=7e+06u
.ends

.subckt w50_l700_nmos$1$1 sky130_fd_pr__nfet_g5v0d10v5$6$1_0/a_n758_n50# sky130_fd_pr__nfet_g5v0d10v5$6$1_0/a_700_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$6$1_0/a_n700_n138# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$6$1_0 sky130_fd_pr__nfet_g5v0d10v5$6$1_0/a_700_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$6$1_0/a_n758_n50# sky130_fd_pr__nfet_g5v0d10v5$6$1_0/a_n700_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$6$1
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$5$1 a_700_n50# a_n700_n147# a_n758_n50# w_n958_n347#
X0 a_700_n50# a_n700_n147# a_n758_n50# w_n958_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=7e+06u
.ends

.subckt w50_l700_pmos$1$1 sky130_fd_pr__pfet_g5v0d10v5$5$1_0/a_700_n50# sky130_fd_pr__pfet_g5v0d10v5$5$1_0/a_n758_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$5$1_0/a_n700_n147# sky130_fd_pr__pfet_g5v0d10v5$5$1_0/w_n958_n347#
Xsky130_fd_pr__pfet_g5v0d10v5$5$1_0 sky130_fd_pr__pfet_g5v0d10v5$5$1_0/a_700_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$5$1_0/a_n700_n147# sky130_fd_pr__pfet_g5v0d10v5$5$1_0/a_n758_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$5$1_0/w_n958_n347# sky130_fd_pr__pfet_g5v0d10v5$5$1
.ends

.subckt x2T1R_w50_l700$1 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$4$1_0/VSUBS
Xw50_l700_nmos$1$1_0 m1_n18719_n21684# RRAM$4$4$1_0/TE w_5419_n25463# RRAM$4$4$1_0/VSUBS
+ w50_l700_nmos$1$1
Xw50_l700_pmos$1$1_0 m1_n18719_n21684# RRAM$4$4$1_0/TE w_41419_n25463# li_n19119_n20024#
+ w50_l700_pmos$1$1
D0 RRAM$4$4$1_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$4$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$1$1$1 a_n500_n138# a_500_n50# a_n692_n272# a_n558_n50#
X0 a_500_n50# a_n500_n138# a_n558_n50# a_n692_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_nmos$1$1 sky130_fd_pr__nfet_g5v0d10v5$1$1$1_0/a_n558_n50# sky130_fd_pr__nfet_g5v0d10v5$1$1$1_0/a_500_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$1$1$1_0/a_n500_n138# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$1$1$1_0 sky130_fd_pr__nfet_g5v0d10v5$1$1$1_0/a_n500_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$1$1$1_0/a_500_n50# VSUBS sky130_fd_pr__nfet_g5v0d10v5$1$1$1_0/a_n558_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$1$1$1
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1$2$1 w_n758_n347# a_500_n50# a_n500_n147# a_n558_n50#
X0 a_500_n50# a_n500_n147# a_n558_n50# w_n758_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=5e+06u
.ends

.subckt w50_l500_pmos$1$1 sky130_fd_pr__pfet_g5v0d10v5$1$2$1_0/a_500_n50# sky130_fd_pr__pfet_g5v0d10v5$1$2$1_0/a_n500_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$2$1_0/a_n558_n50# sky130_fd_pr__pfet_g5v0d10v5$1$2$1_0/w_n758_n347#
Xsky130_fd_pr__pfet_g5v0d10v5$1$2$1_0 sky130_fd_pr__pfet_g5v0d10v5$1$2$1_0/w_n758_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$1$2$1_0/a_500_n50# sky130_fd_pr__pfet_g5v0d10v5$1$2$1_0/a_n500_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$1$2$1_0/a_n558_n50# sky130_fd_pr__pfet_g5v0d10v5$1$2$1
.ends

.subckt x2T1R_w50_l500$1 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$3$1_0/VSUBS
Xw50_l500_nmos$1$1_0 m1_n18719_n21803# RRAM$4$3$1_0/TE w_5419_n25463# RRAM$4$3$1_0/VSUBS
+ w50_l500_nmos$1$1
Xw50_l500_pmos$1$1_0 m1_n18719_n21803# w_41419_n25463# RRAM$4$3$1_0/TE li_n19119_n20673#
+ w50_l500_pmos$1$1
D0 RRAM$4$3$1_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$3$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$1$4 a_n358_n50# a_n300_n147# w_n558_n347# a_300_n50#
X0 a_300_n50# a_n300_n147# a_n358_n50# w_n558_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=3e+06u
.ends

.subckt w50_l300_pmos$2 sky130_fd_pr__pfet_g5v0d10v5$1$4_0/a_n300_n147# sky130_fd_pr__pfet_g5v0d10v5$1$4_0/a_300_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$4_0/w_n558_n347# sky130_fd_pr__pfet_g5v0d10v5$1$4_0/a_n358_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$1$4_0 sky130_fd_pr__pfet_g5v0d10v5$1$4_0/a_n358_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$1$4_0/a_n300_n147# sky130_fd_pr__pfet_g5v0d10v5$1$4_0/w_n558_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$1$4_0/a_300_n50# sky130_fd_pr__pfet_g5v0d10v5$1$4
.ends

.subckt x1T1R_w50_l300_pmos$1 B D DIODE
Xw50_l300_pmos$2_0 w_5419_n25463# D li_n19119_n22791# RRAM$7$1_0/TE w50_l300_pmos$2
D0 RRAM$7$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt x1T1R_NOMOS$1 TOP_ELECTRODE
D0 RRAM$5$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$4$1 a_n358_n50# a_n300_n147# w_n558_n347# a_300_n50#
X0 a_300_n50# a_n300_n147# a_n358_n50# w_n558_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=3e+06u
.ends

.subckt w50_l300_pmos$1$1 sky130_fd_pr__pfet_g5v0d10v5$4$1_0/a_n358_n50# sky130_fd_pr__pfet_g5v0d10v5$4$1_0/a_n300_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$4$1_0/w_n558_n347# sky130_fd_pr__pfet_g5v0d10v5$4$1_0/a_300_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$4$1_0 sky130_fd_pr__pfet_g5v0d10v5$4$1_0/a_n358_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$4$1_0/a_n300_n147# sky130_fd_pr__pfet_g5v0d10v5$4$1_0/w_n558_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$4$1_0/a_300_n50# sky130_fd_pr__pfet_g5v0d10v5$4$1
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$5$1 a_n492_n272# a_n358_n50# a_300_n50# a_n300_n138#
X0 a_300_n50# a_n300_n138# a_n358_n50# a_n492_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=3e+06u
.ends

.subckt w50_l300_nmos$1$1 sky130_fd_pr__nfet_g5v0d10v5$5$1_0/a_300_n50# sky130_fd_pr__nfet_g5v0d10v5$5$1_0/a_n300_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$5$1_0/a_n358_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$5$1_0 VSUBS sky130_fd_pr__nfet_g5v0d10v5$5$1_0/a_n358_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$5$1_0/a_300_n50# sky130_fd_pr__nfet_g5v0d10v5$5$1_0/a_n300_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$5$1
.ends

.subckt x2T1R_w50_l300$1 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$2$1_0/VSUBS
Xw50_l300_pmos$1$1_0 RRAM$4$2$1_0/TE w_41419_n25463# li_n19119_n20775# m1_n18719_n22101#
+ w50_l300_pmos$1$1
Xw50_l300_nmos$1$1_0 RRAM$4$2$1_0/TE w_5419_n25463# m1_n18719_n22101# RRAM$4$2$1_0/VSUBS
+ w50_l300_nmos$1$1
D0 RRAM$4$2$1_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$2$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$4$1$1 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272#
X0 a_100_n50# a_n100_n138# a_n158_n50# a_n292_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_nmos$1$1 sky130_fd_pr__nfet_g5v0d10v5$4$1$1_0/a_n158_n50# sky130_fd_pr__nfet_g5v0d10v5$4$1$1_0/a_n100_n138#
+ sky130_fd_pr__nfet_g5v0d10v5$4$1$1_0/a_100_n50# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$4$1$1_0 sky130_fd_pr__nfet_g5v0d10v5$4$1$1_0/a_100_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$4$1$1_0/a_n100_n138# sky130_fd_pr__nfet_g5v0d10v5$4$1$1_0/a_n158_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$4$1$1
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1 w_n358_n347# a_100_n50# a_n158_n50#
+ a_n100_n147#
X0 a_100_n50# a_n100_n147# a_n158_n50# w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_pmos$1$1 sky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1_0/a_100_n50# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1_0/a_n100_n147#
+ sky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1_0/a_n158_n50# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1_0/w_n358_n347#
Xsky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1_0 sky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1_0/w_n358_n347#
+ sky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1_0/a_100_n50# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1_0/a_n158_n50#
+ sky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1_0/a_n100_n147# sky130_fd_pr__pfet_g5v0d10v5_AQFHUS$1
.ends

.subckt x2T1R_w50_l100$1 G_n G_p DIODE_p DIODE_n B_n B_p D RRAM$4$1$1_0/VSUBS
Xw50_l100_nmos$1$1_0 m1_n18719_n22101# w_5419_n25463# RRAM$4$1$1_0/TE RRAM$4$1$1_0/VSUBS
+ w50_l100_nmos$1$1
Xw50_l100_pmos$1$1_0 m1_n18719_n22101# w_41419_n25463# RRAM$4$1$1_0/TE li_n19119_n20775#
+ w50_l100_pmos$1$1
D0 RRAM$4$1$1_0/VSUBS w_41419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
D1 RRAM$4$1$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5$7 a_n1000_n138# a_1000_n50# a_n1192_n272# a_n1058_n50#
X0 a_1000_n50# a_n1000_n138# a_n1058_n50# a_n1192_n272# sky130_fd_pr__nfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+07u
.ends

.subckt w50_l1000_nmos$2 sky130_fd_pr__nfet_g5v0d10v5$7_0/a_1000_n50# sky130_fd_pr__nfet_g5v0d10v5$7_0/a_n1058_n50#
+ sky130_fd_pr__nfet_g5v0d10v5$7_0/a_n1000_n138# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5$7_0 sky130_fd_pr__nfet_g5v0d10v5$7_0/a_n1000_n138# sky130_fd_pr__nfet_g5v0d10v5$7_0/a_1000_n50#
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5$7_0/a_n1058_n50# sky130_fd_pr__nfet_g5v0d10v5$7
.ends

.subckt x1T1R_w50_l1000_nmos$1 B D DIODE RRAM$11_0/VSUBS
Xw50_l1000_nmos$2_0 RRAM$11_0/TE m1_n18719_n21199# w_5419_n25463# RRAM$11_0/VSUBS
+ w50_l1000_nmos$2
D0 RRAM$11_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5$6 w_n358_n347# a_100_n50# a_n158_n50# a_n100_n147#
X0 a_100_n50# a_n100_n147# a_n158_n50# w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1e+06u
.ends

.subckt w50_l100_pmos$2 sky130_fd_pr__pfet_g5v0d10v5$6_0/a_n100_n147# sky130_fd_pr__pfet_g5v0d10v5$6_0/w_n358_n347#
+ sky130_fd_pr__pfet_g5v0d10v5$6_0/a_n158_n50# sky130_fd_pr__pfet_g5v0d10v5$6_0/a_100_n50#
Xsky130_fd_pr__pfet_g5v0d10v5$6_0 sky130_fd_pr__pfet_g5v0d10v5$6_0/w_n358_n347# sky130_fd_pr__pfet_g5v0d10v5$6_0/a_100_n50#
+ sky130_fd_pr__pfet_g5v0d10v5$6_0/a_n158_n50# sky130_fd_pr__pfet_g5v0d10v5$6_0/a_n100_n147#
+ sky130_fd_pr__pfet_g5v0d10v5$6
.ends

.subckt x1T1R_w50_l100_pmos$1 B D DIODE
Xw50_l100_pmos$2_0 w_5419_n25463# li_n19119_n22791# RRAM$6$1_0/TE D w50_l100_pmos$2
D0 RRAM$6$1_0/VSUBS w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt M1T1R_2T1R_nmos_pmos$1 VSUBS
Xx1T1R_w50_l700_nmos$1_0[0] x1T1R_w50_l700_nmos$1_0[0]/B x1T1R_w50_l700_nmos$1_0[0]/D
+ x1T1R_w50_l700_nmos$1_0[0]/DIODE VSUBS x1T1R_w50_l700_nmos$1
Xx1T1R_w50_l700_nmos$1_0[1] x1T1R_w50_l700_nmos$1_0[1]/B x1T1R_w50_l700_nmos$1_0[1]/D
+ x1T1R_w50_l700_nmos$1_0[1]/DIODE VSUBS x1T1R_w50_l700_nmos$1
Xx1T1R_w50_l700_nmos$1_0[2] x1T1R_w50_l700_nmos$1_0[2]/B x1T1R_w50_l700_nmos$1_0[2]/D
+ x1T1R_w50_l700_nmos$1_0[2]/DIODE VSUBS x1T1R_w50_l700_nmos$1
Xx1T1R_w50_l700_nmos$1_0[3] x1T1R_w50_l700_nmos$1_0[3]/B x1T1R_w50_l700_nmos$1_0[3]/D
+ x1T1R_w50_l700_nmos$1_0[3]/DIODE VSUBS x1T1R_w50_l700_nmos$1
Xx1T1R_w50_l500_nmos$1_0[0] x1T1R_w50_l500_nmos$1_0[0]/B x1T1R_w50_l500_nmos$1_0[0]/D
+ x1T1R_w50_l500_nmos$1_0[0]/DIODE VSUBS x1T1R_w50_l500_nmos$1
Xx1T1R_w50_l500_nmos$1_0[1] x1T1R_w50_l500_nmos$1_0[1]/B x1T1R_w50_l500_nmos$1_0[1]/D
+ x1T1R_w50_l500_nmos$1_0[1]/DIODE VSUBS x1T1R_w50_l500_nmos$1
Xx1T1R_w50_l500_nmos$1_0[2] x1T1R_w50_l500_nmos$1_0[2]/B x1T1R_w50_l500_nmos$1_0[2]/D
+ x1T1R_w50_l500_nmos$1_0[2]/DIODE VSUBS x1T1R_w50_l500_nmos$1
Xx1T1R_w50_l500_nmos$1_0[3] x1T1R_w50_l500_nmos$1_0[3]/B x1T1R_w50_l500_nmos$1_0[3]/D
+ x1T1R_w50_l500_nmos$1_0[3]/DIODE VSUBS x1T1R_w50_l500_nmos$1
Xx1T1R_w50_l1000_pmos$1_0 x1T1R_w50_l1000_pmos$1_0/B x1T1R_w50_l1000_pmos$1_0/D x1T1R_w50_l1000_pmos$1_0/DIODE
+ x1T1R_w50_l1000_pmos$1
Xx1T1R_w50_l1000_pmos$1_1[0] x1T1R_w50_l1000_pmos$1_1[0]/B x1T1R_w50_l1000_pmos$1_1[0]/D
+ x1T1R_w50_l1000_pmos$1_1[0]/DIODE x1T1R_w50_l1000_pmos$1
Xx1T1R_w50_l1000_pmos$1_1[1] x1T1R_w50_l1000_pmos$1_1[1]/B x1T1R_w50_l1000_pmos$1_1[1]/D
+ x1T1R_w50_l1000_pmos$1_1[1]/DIODE x1T1R_w50_l1000_pmos$1
Xx1T1R_w50_l1000_pmos$1_1[2] x1T1R_w50_l1000_pmos$1_1[2]/B x1T1R_w50_l1000_pmos$1_1[2]/D
+ x1T1R_w50_l1000_pmos$1_1[2]/DIODE x1T1R_w50_l1000_pmos$1
Xx1T1R_w50_l700_pmos$1_0 x1T1R_w50_l700_pmos$1_0/B x1T1R_w50_l700_pmos$1_0/D x1T1R_w50_l700_pmos$1_0/DIODE
+ x1T1R_w50_l700_pmos$1
Xx1T1R_w50_l300_nmos$1_0 x1T1R_w50_l300_nmos$1_0/B x1T1R_w50_l300_nmos$1_0/D x1T1R_w50_l300_nmos$1_0/DIODE
+ VSUBS x1T1R_w50_l300_nmos$1
Xx1T1R_w50_l700_pmos$1_1[0] x1T1R_w50_l700_pmos$1_1[0]/B x1T1R_w50_l700_pmos$1_1[0]/D
+ x1T1R_w50_l700_pmos$1_1[0]/DIODE x1T1R_w50_l700_pmos$1
Xx1T1R_w50_l700_pmos$1_1[1] x1T1R_w50_l700_pmos$1_1[1]/B x1T1R_w50_l700_pmos$1_1[1]/D
+ x1T1R_w50_l700_pmos$1_1[1]/DIODE x1T1R_w50_l700_pmos$1
Xx1T1R_w50_l700_pmos$1_1[2] x1T1R_w50_l700_pmos$1_1[2]/B x1T1R_w50_l700_pmos$1_1[2]/D
+ x1T1R_w50_l700_pmos$1_1[2]/DIODE x1T1R_w50_l700_pmos$1
Xx1T1R_w50_l300_nmos$1_1[0] x1T1R_w50_l300_nmos$1_1[0]/B x1T1R_w50_l300_nmos$1_1[0]/D
+ x1T1R_w50_l300_nmos$1_1[0]/DIODE VSUBS x1T1R_w50_l300_nmos$1
Xx1T1R_w50_l300_nmos$1_1[1] x1T1R_w50_l300_nmos$1_1[1]/B x1T1R_w50_l300_nmos$1_1[1]/D
+ x1T1R_w50_l300_nmos$1_1[1]/DIODE VSUBS x1T1R_w50_l300_nmos$1
Xx1T1R_w50_l300_nmos$1_1[2] x1T1R_w50_l300_nmos$1_1[2]/B x1T1R_w50_l300_nmos$1_1[2]/D
+ x1T1R_w50_l300_nmos$1_1[2]/DIODE VSUBS x1T1R_w50_l300_nmos$1
Xx1T1R_w50_l300_nmos$1_1[3] x1T1R_w50_l300_nmos$1_1[3]/B x1T1R_w50_l300_nmos$1_1[3]/D
+ x1T1R_w50_l300_nmos$1_1[3]/DIODE VSUBS x1T1R_w50_l300_nmos$1
Xx2T1R_w50_l1000$1_0[0] x2T1R_w50_l1000$1_0[0]/G_n x2T1R_w50_l1000$1_0[0]/G_p x2T1R_w50_l1000$1_0[0]/DIODE_p
+ x2T1R_w50_l1000$1_0[0]/DIODE_n x2T1R_w50_l1000$1_0[0]/B_n x2T1R_w50_l1000$1_0[0]/B_p
+ x2T1R_w50_l1000$1_0[0]/D VSUBS x2T1R_w50_l1000$1
Xx2T1R_w50_l1000$1_0[1] x2T1R_w50_l1000$1_0[1]/G_n x2T1R_w50_l1000$1_0[1]/G_p x2T1R_w50_l1000$1_0[1]/DIODE_p
+ x2T1R_w50_l1000$1_0[1]/DIODE_n x2T1R_w50_l1000$1_0[1]/B_n x2T1R_w50_l1000$1_0[1]/B_p
+ x2T1R_w50_l1000$1_0[1]/D VSUBS x2T1R_w50_l1000$1
Xx2T1R_w50_l1000$1_0[2] x2T1R_w50_l1000$1_0[2]/G_n x2T1R_w50_l1000$1_0[2]/G_p x2T1R_w50_l1000$1_0[2]/DIODE_p
+ x2T1R_w50_l1000$1_0[2]/DIODE_n x2T1R_w50_l1000$1_0[2]/B_n x2T1R_w50_l1000$1_0[2]/B_p
+ x2T1R_w50_l1000$1_0[2]/D VSUBS x2T1R_w50_l1000$1
Xx2T1R_w50_l1000$1_1[0] x2T1R_w50_l1000$1_1[0]/G_n x2T1R_w50_l1000$1_1[0]/G_p x2T1R_w50_l1000$1_1[0]/DIODE_p
+ x2T1R_w50_l1000$1_1[0]/DIODE_n x2T1R_w50_l1000$1_1[0]/B_n x2T1R_w50_l1000$1_1[0]/B_p
+ x2T1R_w50_l1000$1_1[0]/D VSUBS x2T1R_w50_l1000$1
Xx2T1R_w50_l1000$1_1[1] x2T1R_w50_l1000$1_1[1]/G_n x2T1R_w50_l1000$1_1[1]/G_p x2T1R_w50_l1000$1_1[1]/DIODE_p
+ x2T1R_w50_l1000$1_1[1]/DIODE_n x2T1R_w50_l1000$1_1[1]/B_n x2T1R_w50_l1000$1_1[1]/B_p
+ x2T1R_w50_l1000$1_1[1]/D VSUBS x2T1R_w50_l1000$1
Xx2T1R_w50_l1000$1_1[2] x2T1R_w50_l1000$1_1[2]/G_n x2T1R_w50_l1000$1_1[2]/G_p x2T1R_w50_l1000$1_1[2]/DIODE_p
+ x2T1R_w50_l1000$1_1[2]/DIODE_n x2T1R_w50_l1000$1_1[2]/B_n x2T1R_w50_l1000$1_1[2]/B_p
+ x2T1R_w50_l1000$1_1[2]/D VSUBS x2T1R_w50_l1000$1
Xx1T1R_w50_l500_pmos$1_0[0] x1T1R_w50_l500_pmos$1_0[0]/B x1T1R_w50_l500_pmos$1_0[0]/D
+ x1T1R_w50_l500_pmos$1_0[0]/DIODE x1T1R_w50_l500_pmos$1
Xx1T1R_w50_l500_pmos$1_0[1] x1T1R_w50_l500_pmos$1_0[1]/B x1T1R_w50_l500_pmos$1_0[1]/D
+ x1T1R_w50_l500_pmos$1_0[1]/DIODE x1T1R_w50_l500_pmos$1
Xx1T1R_w50_l500_pmos$1_0[2] x1T1R_w50_l500_pmos$1_0[2]/B x1T1R_w50_l500_pmos$1_0[2]/D
+ x1T1R_w50_l500_pmos$1_0[2]/DIODE x1T1R_w50_l500_pmos$1
Xx1T1R_w50_l100_nmos$1_0[0] x1T1R_w50_l100_nmos$1_0[0]/B x1T1R_w50_l100_nmos$1_0[0]/D
+ x1T1R_w50_l100_nmos$1_0[0]/DIODE VSUBS x1T1R_w50_l100_nmos$1
Xx1T1R_w50_l100_nmos$1_0[1] x1T1R_w50_l100_nmos$1_0[1]/B x1T1R_w50_l100_nmos$1_0[1]/D
+ x1T1R_w50_l100_nmos$1_0[1]/DIODE VSUBS x1T1R_w50_l100_nmos$1
Xx1T1R_w50_l100_nmos$1_0[2] x1T1R_w50_l100_nmos$1_0[2]/B x1T1R_w50_l100_nmos$1_0[2]/D
+ x1T1R_w50_l100_nmos$1_0[2]/DIODE VSUBS x1T1R_w50_l100_nmos$1
Xx1T1R_w50_l100_nmos$1_0[3] x1T1R_w50_l100_nmos$1_0[3]/B x1T1R_w50_l100_nmos$1_0[3]/D
+ x1T1R_w50_l100_nmos$1_0[3]/DIODE VSUBS x1T1R_w50_l100_nmos$1
Xx1T1R_w50_l500_pmos$1_1 x1T1R_w50_l500_pmos$1_1/B x1T1R_w50_l500_pmos$1_1/D x1T1R_w50_l500_pmos$1_1/DIODE
+ x1T1R_w50_l500_pmos$1
Xx2T1R_w50_l700$1_0[0] x2T1R_w50_l700$1_0[0]/G_n x2T1R_w50_l700$1_0[0]/G_p x2T1R_w50_l700$1_0[0]/DIODE_p
+ x2T1R_w50_l700$1_0[0]/DIODE_n x2T1R_w50_l700$1_0[0]/B_n x2T1R_w50_l700$1_0[0]/B_p
+ x2T1R_w50_l700$1_0[0]/D VSUBS x2T1R_w50_l700$1
Xx2T1R_w50_l700$1_0[1] x2T1R_w50_l700$1_0[1]/G_n x2T1R_w50_l700$1_0[1]/G_p x2T1R_w50_l700$1_0[1]/DIODE_p
+ x2T1R_w50_l700$1_0[1]/DIODE_n x2T1R_w50_l700$1_0[1]/B_n x2T1R_w50_l700$1_0[1]/B_p
+ x2T1R_w50_l700$1_0[1]/D VSUBS x2T1R_w50_l700$1
Xx2T1R_w50_l700$1_0[2] x2T1R_w50_l700$1_0[2]/G_n x2T1R_w50_l700$1_0[2]/G_p x2T1R_w50_l700$1_0[2]/DIODE_p
+ x2T1R_w50_l700$1_0[2]/DIODE_n x2T1R_w50_l700$1_0[2]/B_n x2T1R_w50_l700$1_0[2]/B_p
+ x2T1R_w50_l700$1_0[2]/D VSUBS x2T1R_w50_l700$1
Xx2T1R_w50_l700$1_1[0] x2T1R_w50_l700$1_1[0]/G_n x2T1R_w50_l700$1_1[0]/G_p x2T1R_w50_l700$1_1[0]/DIODE_p
+ x2T1R_w50_l700$1_1[0]/DIODE_n x2T1R_w50_l700$1_1[0]/B_n x2T1R_w50_l700$1_1[0]/B_p
+ x2T1R_w50_l700$1_1[0]/D VSUBS x2T1R_w50_l700$1
Xx2T1R_w50_l700$1_1[1] x2T1R_w50_l700$1_1[1]/G_n x2T1R_w50_l700$1_1[1]/G_p x2T1R_w50_l700$1_1[1]/DIODE_p
+ x2T1R_w50_l700$1_1[1]/DIODE_n x2T1R_w50_l700$1_1[1]/B_n x2T1R_w50_l700$1_1[1]/B_p
+ x2T1R_w50_l700$1_1[1]/D VSUBS x2T1R_w50_l700$1
Xx2T1R_w50_l700$1_1[2] x2T1R_w50_l700$1_1[2]/G_n x2T1R_w50_l700$1_1[2]/G_p x2T1R_w50_l700$1_1[2]/DIODE_p
+ x2T1R_w50_l700$1_1[2]/DIODE_n x2T1R_w50_l700$1_1[2]/B_n x2T1R_w50_l700$1_1[2]/B_p
+ x2T1R_w50_l700$1_1[2]/D VSUBS x2T1R_w50_l700$1
Xx2T1R_w50_l500$1_0[0] x2T1R_w50_l500$1_0[0]/G_n x2T1R_w50_l500$1_0[0]/G_p x2T1R_w50_l500$1_0[0]/DIODE_p
+ x2T1R_w50_l500$1_0[0]/DIODE_n x2T1R_w50_l500$1_0[0]/B_n x2T1R_w50_l500$1_0[0]/B_p
+ x2T1R_w50_l500$1_0[0]/D VSUBS x2T1R_w50_l500$1
Xx2T1R_w50_l500$1_0[1] x2T1R_w50_l500$1_0[1]/G_n x2T1R_w50_l500$1_0[1]/G_p x2T1R_w50_l500$1_0[1]/DIODE_p
+ x2T1R_w50_l500$1_0[1]/DIODE_n x2T1R_w50_l500$1_0[1]/B_n x2T1R_w50_l500$1_0[1]/B_p
+ x2T1R_w50_l500$1_0[1]/D VSUBS x2T1R_w50_l500$1
Xx2T1R_w50_l500$1_0[2] x2T1R_w50_l500$1_0[2]/G_n x2T1R_w50_l500$1_0[2]/G_p x2T1R_w50_l500$1_0[2]/DIODE_p
+ x2T1R_w50_l500$1_0[2]/DIODE_n x2T1R_w50_l500$1_0[2]/B_n x2T1R_w50_l500$1_0[2]/B_p
+ x2T1R_w50_l500$1_0[2]/D VSUBS x2T1R_w50_l500$1
Xx1T1R_w50_l300_pmos$1_0[0] x1T1R_w50_l300_pmos$1_0[0]/B x1T1R_w50_l300_pmos$1_0[0]/D
+ x1T1R_w50_l300_pmos$1_0[0]/DIODE x1T1R_w50_l300_pmos$1
Xx1T1R_w50_l300_pmos$1_0[1] x1T1R_w50_l300_pmos$1_0[1]/B x1T1R_w50_l300_pmos$1_0[1]/D
+ x1T1R_w50_l300_pmos$1_0[1]/DIODE x1T1R_w50_l300_pmos$1
Xx1T1R_w50_l300_pmos$1_0[2] x1T1R_w50_l300_pmos$1_0[2]/B x1T1R_w50_l300_pmos$1_0[2]/D
+ x1T1R_w50_l300_pmos$1_0[2]/DIODE x1T1R_w50_l300_pmos$1
Xx1T1R_NOMOS$1_0 x1T1R_NOMOS$1_0/TOP_ELECTRODE x1T1R_NOMOS$1
Xx2T1R_w50_l500$1_1[0] x2T1R_w50_l500$1_1[0]/G_n x2T1R_w50_l500$1_1[0]/G_p x2T1R_w50_l500$1_1[0]/DIODE_p
+ x2T1R_w50_l500$1_1[0]/DIODE_n x2T1R_w50_l500$1_1[0]/B_n x2T1R_w50_l500$1_1[0]/B_p
+ x2T1R_w50_l500$1_1[0]/D VSUBS x2T1R_w50_l500$1
Xx2T1R_w50_l500$1_1[1] x2T1R_w50_l500$1_1[1]/G_n x2T1R_w50_l500$1_1[1]/G_p x2T1R_w50_l500$1_1[1]/DIODE_p
+ x2T1R_w50_l500$1_1[1]/DIODE_n x2T1R_w50_l500$1_1[1]/B_n x2T1R_w50_l500$1_1[1]/B_p
+ x2T1R_w50_l500$1_1[1]/D VSUBS x2T1R_w50_l500$1
Xx2T1R_w50_l500$1_1[2] x2T1R_w50_l500$1_1[2]/G_n x2T1R_w50_l500$1_1[2]/G_p x2T1R_w50_l500$1_1[2]/DIODE_p
+ x2T1R_w50_l500$1_1[2]/DIODE_n x2T1R_w50_l500$1_1[2]/B_n x2T1R_w50_l500$1_1[2]/B_p
+ x2T1R_w50_l500$1_1[2]/D VSUBS x2T1R_w50_l500$1
Xx1T1R_NOMOS$1_1[0] x1T1R_NOMOS$1_1[0]/TOP_ELECTRODE x1T1R_NOMOS$1
Xx1T1R_NOMOS$1_1[1] x1T1R_NOMOS$1_1[1]/TOP_ELECTRODE x1T1R_NOMOS$1
Xx1T1R_NOMOS$1_1[2] x1T1R_NOMOS$1_1[2]/TOP_ELECTRODE x1T1R_NOMOS$1
Xx2T1R_w50_l300$1_0[0] x2T1R_w50_l300$1_0[0]/G_n x2T1R_w50_l300$1_0[0]/G_p x2T1R_w50_l300$1_0[0]/DIODE_p
+ x2T1R_w50_l300$1_0[0]/DIODE_n x2T1R_w50_l300$1_0[0]/B_n x2T1R_w50_l300$1_0[0]/B_p
+ x2T1R_w50_l300$1_0[0]/D VSUBS x2T1R_w50_l300$1
Xx2T1R_w50_l300$1_0[1] x2T1R_w50_l300$1_0[1]/G_n x2T1R_w50_l300$1_0[1]/G_p x2T1R_w50_l300$1_0[1]/DIODE_p
+ x2T1R_w50_l300$1_0[1]/DIODE_n x2T1R_w50_l300$1_0[1]/B_n x2T1R_w50_l300$1_0[1]/B_p
+ x2T1R_w50_l300$1_0[1]/D VSUBS x2T1R_w50_l300$1
Xx2T1R_w50_l300$1_0[2] x2T1R_w50_l300$1_0[2]/G_n x2T1R_w50_l300$1_0[2]/G_p x2T1R_w50_l300$1_0[2]/DIODE_p
+ x2T1R_w50_l300$1_0[2]/DIODE_n x2T1R_w50_l300$1_0[2]/B_n x2T1R_w50_l300$1_0[2]/B_p
+ x2T1R_w50_l300$1_0[2]/D VSUBS x2T1R_w50_l300$1
Xx1T1R_NOMOS$1_2[0] x1T1R_NOMOS$1_2[0]/TOP_ELECTRODE x1T1R_NOMOS$1
Xx1T1R_NOMOS$1_2[1] x1T1R_NOMOS$1_2[1]/TOP_ELECTRODE x1T1R_NOMOS$1
Xx1T1R_NOMOS$1_2[2] x1T1R_NOMOS$1_2[2]/TOP_ELECTRODE x1T1R_NOMOS$1
Xx1T1R_NOMOS$1_2[3] x1T1R_NOMOS$1_2[3]/TOP_ELECTRODE x1T1R_NOMOS$1
Xx2T1R_w50_l300$1_1[0] x2T1R_w50_l300$1_1[0]/G_n x2T1R_w50_l300$1_1[0]/G_p x2T1R_w50_l300$1_1[0]/DIODE_p
+ x2T1R_w50_l300$1_1[0]/DIODE_n x2T1R_w50_l300$1_1[0]/B_n x2T1R_w50_l300$1_1[0]/B_p
+ x2T1R_w50_l300$1_1[0]/D VSUBS x2T1R_w50_l300$1
Xx2T1R_w50_l300$1_1[1] x2T1R_w50_l300$1_1[1]/G_n x2T1R_w50_l300$1_1[1]/G_p x2T1R_w50_l300$1_1[1]/DIODE_p
+ x2T1R_w50_l300$1_1[1]/DIODE_n x2T1R_w50_l300$1_1[1]/B_n x2T1R_w50_l300$1_1[1]/B_p
+ x2T1R_w50_l300$1_1[1]/D VSUBS x2T1R_w50_l300$1
Xx2T1R_w50_l300$1_1[2] x2T1R_w50_l300$1_1[2]/G_n x2T1R_w50_l300$1_1[2]/G_p x2T1R_w50_l300$1_1[2]/DIODE_p
+ x2T1R_w50_l300$1_1[2]/DIODE_n x2T1R_w50_l300$1_1[2]/B_n x2T1R_w50_l300$1_1[2]/B_p
+ x2T1R_w50_l300$1_1[2]/D VSUBS x2T1R_w50_l300$1
Xx2T1R_w50_l100$1_0[0] x2T1R_w50_l100$1_0[0]/G_n x2T1R_w50_l100$1_0[0]/G_p x2T1R_w50_l100$1_0[0]/DIODE_p
+ x2T1R_w50_l100$1_0[0]/DIODE_n x2T1R_w50_l100$1_0[0]/B_n x2T1R_w50_l100$1_0[0]/B_p
+ x2T1R_w50_l100$1_0[0]/D VSUBS x2T1R_w50_l100$1
Xx2T1R_w50_l100$1_0[1] x2T1R_w50_l100$1_0[1]/G_n x2T1R_w50_l100$1_0[1]/G_p x2T1R_w50_l100$1_0[1]/DIODE_p
+ x2T1R_w50_l100$1_0[1]/DIODE_n x2T1R_w50_l100$1_0[1]/B_n x2T1R_w50_l100$1_0[1]/B_p
+ x2T1R_w50_l100$1_0[1]/D VSUBS x2T1R_w50_l100$1
Xx2T1R_w50_l100$1_0[2] x2T1R_w50_l100$1_0[2]/G_n x2T1R_w50_l100$1_0[2]/G_p x2T1R_w50_l100$1_0[2]/DIODE_p
+ x2T1R_w50_l100$1_0[2]/DIODE_n x2T1R_w50_l100$1_0[2]/B_n x2T1R_w50_l100$1_0[2]/B_p
+ x2T1R_w50_l100$1_0[2]/D VSUBS x2T1R_w50_l100$1
Xx1T1R_w50_l1000_nmos$1_0[0] x1T1R_w50_l1000_nmos$1_0[0]/B x1T1R_w50_l1000_nmos$1_0[0]/D
+ x1T1R_w50_l1000_nmos$1_0[0]/DIODE VSUBS x1T1R_w50_l1000_nmos$1
Xx1T1R_w50_l1000_nmos$1_0[1] x1T1R_w50_l1000_nmos$1_0[1]/B x1T1R_w50_l1000_nmos$1_0[1]/D
+ x1T1R_w50_l1000_nmos$1_0[1]/DIODE VSUBS x1T1R_w50_l1000_nmos$1
Xx1T1R_w50_l1000_nmos$1_0[2] x1T1R_w50_l1000_nmos$1_0[2]/B x1T1R_w50_l1000_nmos$1_0[2]/D
+ x1T1R_w50_l1000_nmos$1_0[2]/DIODE VSUBS x1T1R_w50_l1000_nmos$1
Xx1T1R_w50_l1000_nmos$1_0[3] x1T1R_w50_l1000_nmos$1_0[3]/B x1T1R_w50_l1000_nmos$1_0[3]/D
+ x1T1R_w50_l1000_nmos$1_0[3]/DIODE VSUBS x1T1R_w50_l1000_nmos$1
Xx2T1R_w50_l100$1_1[0] x2T1R_w50_l100$1_1[0]/G_n x2T1R_w50_l100$1_1[0]/G_p x2T1R_w50_l100$1_1[0]/DIODE_p
+ x2T1R_w50_l100$1_1[0]/DIODE_n x2T1R_w50_l100$1_1[0]/B_n x2T1R_w50_l100$1_1[0]/B_p
+ x2T1R_w50_l100$1_1[0]/D VSUBS x2T1R_w50_l100$1
Xx2T1R_w50_l100$1_1[1] x2T1R_w50_l100$1_1[1]/G_n x2T1R_w50_l100$1_1[1]/G_p x2T1R_w50_l100$1_1[1]/DIODE_p
+ x2T1R_w50_l100$1_1[1]/DIODE_n x2T1R_w50_l100$1_1[1]/B_n x2T1R_w50_l100$1_1[1]/B_p
+ x2T1R_w50_l100$1_1[1]/D VSUBS x2T1R_w50_l100$1
Xx2T1R_w50_l100$1_1[2] x2T1R_w50_l100$1_1[2]/G_n x2T1R_w50_l100$1_1[2]/G_p x2T1R_w50_l100$1_1[2]/DIODE_p
+ x2T1R_w50_l100$1_1[2]/DIODE_n x2T1R_w50_l100$1_1[2]/B_n x2T1R_w50_l100$1_1[2]/B_p
+ x2T1R_w50_l100$1_1[2]/D VSUBS x2T1R_w50_l100$1
Xx1T1R_w50_l100_pmos$1_0 x1T1R_w50_l100_pmos$1_0/B x1T1R_w50_l100_pmos$1_0/D x1T1R_w50_l100_pmos$1_0/DIODE
+ x1T1R_w50_l100_pmos$1
Xx1T1R_w50_l100_pmos$1_1[0] x1T1R_w50_l100_pmos$1_1[0]/B x1T1R_w50_l100_pmos$1_1[0]/D
+ x1T1R_w50_l100_pmos$1_1[0]/DIODE x1T1R_w50_l100_pmos$1
Xx1T1R_w50_l100_pmos$1_1[1] x1T1R_w50_l100_pmos$1_1[1]/B x1T1R_w50_l100_pmos$1_1[1]/D
+ x1T1R_w50_l100_pmos$1_1[1]/DIODE x1T1R_w50_l100_pmos$1
Xx1T1R_w50_l100_pmos$1_1[2] x1T1R_w50_l100_pmos$1_1[2]/B x1T1R_w50_l100_pmos$1_1[2]/D
+ x1T1R_w50_l100_pmos$1_1[2]/DIODE x1T1R_w50_l100_pmos$1
.ends

.subckt X7$1$2 a_n7416_n4222# a_n7330_n4062# a_n7242_n4120# a_n7242_n2462#
X0 a_n7242_n2462# a_n7330_n4062# a_n7242_n4120# a_n7416_n4222# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X6$1$2 a_n7694_n2470# a_n7694_n4128# a_n7868_n4230# a_n7782_n4070#
X0 a_n7694_n2470# a_n7782_n4070# a_n7694_n4128# a_n7868_n4230# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X5$1$2 a_n5018_n1474# a_n5018_184# a_n5192_n1576# a_n5106_n1416#
X0 a_n5018_184# a_n5106_n1416# a_n5018_n1474# a_n5192_n1576# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X4$1$2 a_n5074_164# a_n5248_n1596# a_n5074_n1494# a_n5162_n1436#
X0 a_n5074_164# a_n5162_n1436# a_n5074_n1494# a_n5248_n1596# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pad$1$1$2 single_pad$4$1$2_0[1|0]/m1_n4000_4006# single_pad$4$1$2_0[3|1]/m1_n4000_4006#
+ single_pad$4$1$2_0[0|1]/m1_n4000_4006# single_pad$4$1$2_0[3|0]/m1_n4000_4006# single_pad$4$1$2_0[0|0]/m1_n4000_4006#
+ single_pad$4$1$2_0[2|1]/m1_n4000_4006# single_pad$4$1$2_0[2|0]/m1_n4000_4006# single_pad$4$1$2_0[1|1]/m1_n4000_4006#
.ends

.subckt X3$1$2 a_n5022_n1696# a_n5022_n38# a_n5196_n1798# a_n5110_n1638#
X0 a_n5022_n38# a_n5110_n1638# a_n5022_n1696# a_n5196_n1798# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X2$1$2 a_n5254_n1836# a_n5168_n1676# a_n5080_n1734# a_n5080_n76#
X0 a_n5080_n76# a_n5168_n1676# a_n5080_n1734# a_n5254_n1836# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X1$1$2 w_n5371_n1923# a_n5223_n127# a_n5223_n1785# a_n5249_n1727#
X0 a_n5223_n127# a_n5249_n1727# a_n5223_n1785# w_n5371_n1923# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X0$1$2 a_n5109_n1805# a_n5135_n1747# w_n5257_n1943# a_n5109_n147#
X0 a_n5109_n147# a_n5135_n1747# a_n5109_n1805# w_n5257_n1943# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pseudo_resistor_s8$1  Vin Vdd  Vcontrol2  v1 v2  Vcontrol1  Vout vgnd
XX7$1$2_0 vgnd  Vcontrol2 v2 vgnd X7$1$2
XX6$1$2_0 vgnd v2 vgnd  Vcontrol1 X6$1$2
XX5$1$2_0  v1 vgnd vgnd  Vcontrol2 X5$1$2
XX4$1$2_0 vgnd vgnd  v1  Vcontrol1 X4$1$2
Xpad$1$1$2_0  Vcontrol2  Vout v2  Vcontrol1 vgnd m1_n8466_31# m1_n12430_4307#  v1
+ pad$1$1$2
XX3$1$2_0 m1_n12430_4307# v2 vgnd  Vout X3$1$2
XX2$1$2_0 vgnd m1_n8466_31# m1_n12430_4307#  v1 X2$1$2
XX1$1$2_0  Vout  Vout m1_n7863_n1622# v2 X1$1$2
XX0$1$2_0 m1_n7863_n1622#  v1 m1_n8466_31# m1_n8466_31# X0$1$2
.ends

.subckt pseudoResistorS8Array$1 VSUBS
Xpseudo_resistor_s8$1_0[0] pseudo_resistor_s8$1_0[0]/ Vin pseudo_resistor_s8$1_0[0]/Vdd
+ pseudo_resistor_s8$1_0[0]/ Vcontrol2 pseudo_resistor_s8$1_0[0]/ v1 pseudo_resistor_s8$1_0[0]/v2
+ pseudo_resistor_s8$1_0[0]/ Vcontrol1 pseudo_resistor_s8$1_0[0]/ Vout VSUBS pseudo_resistor_s8$1
Xpseudo_resistor_s8$1_0[1] pseudo_resistor_s8$1_0[1]/ Vin pseudo_resistor_s8$1_0[1]/Vdd
+ pseudo_resistor_s8$1_0[1]/ Vcontrol2 pseudo_resistor_s8$1_0[1]/ v1 pseudo_resistor_s8$1_0[1]/v2
+ pseudo_resistor_s8$1_0[1]/ Vcontrol1 pseudo_resistor_s8$1_0[1]/ Vout VSUBS pseudo_resistor_s8$1
Xpseudo_resistor_s8$1_0[2] pseudo_resistor_s8$1_0[2]/ Vin pseudo_resistor_s8$1_0[2]/Vdd
+ pseudo_resistor_s8$1_0[2]/ Vcontrol2 pseudo_resistor_s8$1_0[2]/ v1 pseudo_resistor_s8$1_0[2]/v2
+ pseudo_resistor_s8$1_0[2]/ Vcontrol1 pseudo_resistor_s8$1_0[2]/ Vout VSUBS pseudo_resistor_s8$1
Xpseudo_resistor_s8$1_0[3] pseudo_resistor_s8$1_0[3]/ Vin pseudo_resistor_s8$1_0[3]/Vdd
+ pseudo_resistor_s8$1_0[3]/ Vcontrol2 pseudo_resistor_s8$1_0[3]/ v1 pseudo_resistor_s8$1_0[3]/v2
+ pseudo_resistor_s8$1_0[3]/ Vcontrol1 pseudo_resistor_s8$1_0[3]/ Vout VSUBS pseudo_resistor_s8$1
.ends

.subckt sky130_fd_pr__pfet_01v8$1$1 a_800_n78# a_n800_n104# a_n858_n78# w_n996_n226#
X0 a_800_n78# a_n800_n104# a_n858_n78# w_n996_n226# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pmos_l8u$2 G Vdd D
Xpmos D G m1_n259_333# m1_n259_333# sky130_fd_pr__pfet_01v8$1$1
.ends

.subckt singlePmosArray$1
Xpmos_l8u$2_0[0] pmos_l8u$2_0[0]/G pmos_l8u$2_0[0]/Vdd pmos_l8u$2_0[0]/D pmos_l8u$2
Xpmos_l8u$2_0[1] pmos_l8u$2_0[1]/G pmos_l8u$2_0[1]/Vdd pmos_l8u$2_0[1]/D pmos_l8u$2
Xpmos_l8u$2_0[2] pmos_l8u$2_0[2]/G pmos_l8u$2_0[2]/Vdd pmos_l8u$2_0[2]/D pmos_l8u$2
Xpmos_l8u$2_0[3] pmos_l8u$2_0[3]/G pmos_l8u$2_0[3]/Vdd pmos_l8u$2_0[3]/D pmos_l8u$2
Xpmos_l8u$2_0[4] pmos_l8u$2_0[4]/G pmos_l8u$2_0[4]/Vdd pmos_l8u$2_0[4]/D pmos_l8u$2
.ends

.subckt sky130_fd_pr__nfet_01v8$1$1 a_143_69# a_n17_n17# a_1743_95# a_85_95#
X0 a_1743_95# a_143_69# a_85_95# a_n17_n17# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt nmos_l8u$2 G D vgnd VSUBS
Xsky130_fd_pr__nfet_01v8$1$1_0 G VSUBS D VSUBS sky130_fd_pr__nfet_01v8$1$1
.ends

.subckt singleNmosArray$1 VSUBS
Xnmos_l8u$2_0[0] nmos_l8u$2_0[0]/G nmos_l8u$2_0[0]/D nmos_l8u$2_0[0]/vgnd VSUBS nmos_l8u$2
Xnmos_l8u$2_0[1] nmos_l8u$2_0[1]/G nmos_l8u$2_0[1]/D nmos_l8u$2_0[1]/vgnd VSUBS nmos_l8u$2
Xnmos_l8u$2_0[2] nmos_l8u$2_0[2]/G nmos_l8u$2_0[2]/D nmos_l8u$2_0[2]/vgnd VSUBS nmos_l8u$2
Xnmos_l8u$2_0[3] nmos_l8u$2_0[3]/G nmos_l8u$2_0[3]/D nmos_l8u$2_0[3]/vgnd VSUBS nmos_l8u$2
Xnmos_l8u$2_0[4] nmos_l8u$2_0[4]/G nmos_l8u$2_0[4]/D nmos_l8u$2_0[4]/vgnd VSUBS nmos_l8u$2
.ends

.subckt tie_down$1 w_5419_n25463#
D0 a_5317_n25565# w_5419_n25463# sky130_fd_pr__diode_pd2nw_05v5 pj=1.8e+06u area=2.025e+11p
.ends

.subckt pad$1 single_pad$3$1_0[2|0]/m1_n12006_n4000# single_pad$3$1_0[0|1]/m1_n12006_n4000#
+ single_pad$3$1_0[1|0]/m1_n12006_n4000# single_pad$3$1_0[4|1]/m1_n12006_n4000# single_pad$3$1_0[0|0]/m1_n12006_n4000#
+ single_pad$3$1_0[3|1]/m1_n12006_n4000# single_pad$3$1_0[2|1]/m1_n12006_n4000# single_pad$3$1_0[4|0]/m1_n12006_n4000#
+ single_pad$3$1_0[1|1]/m1_n12006_n4000# single_pad$3$1_0[3|0]/m1_n12006_n4000#
.ends

.subckt RRAM_bridge$1 Vb_2 vgnd DIODE_2 DIODE_1 Vdd D_2 Vb_1 D_1 G_2 G_1 TE pad$1_0/VSUBS
Xtie_down$1_0 a_26470_n17436# tie_down$1
Xtie_down$1_1 a_26470_n57# tie_down$1
Xpad$1_0 Vb_1 a_26470_n57# TE pad$1_0/VSUBS a_26470_n17436# a_26470_n17436# a_14718_n17285#
+ a_26570_n17410# a_26470_n57# TE pad$1
X0 a_26570_n17410# a_26470_n17436# TE pad$1_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.03e+12p pd=1.458e+07u as=4.06e+12p ps=2.916e+07u w=7e+06u l=500000u
X1 a_14718_n17285# TE pad$1_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
X2 Vb_1 a_26470_n57# TE pad$1_0/VSUBS sky130_fd_pr__nfet_g5v0d10v5 ad=2.03e+12p pd=1.458e+07u as=0p ps=0u w=7e+06u l=500000u
X3 a_14718_n17285# TE pad$1_0/VSUBS sky130_fd_pr__res_generic_nd w=420000u l=4.91336e+09u
.ends

.subckt RRAM_bridgeArray$1 VSUBS
XRRAM_bridge$1_0 RRAM_bridge$1_0/Vb_2 RRAM_bridge$1_0/vgnd RRAM_bridge$1_0/DIODE_2
+ RRAM_bridge$1_0/DIODE_1 RRAM_bridge$1_0/Vdd RRAM_bridge$1_0/D_2 RRAM_bridge$1_0/Vb_1
+ RRAM_bridge$1_0/D_1 RRAM_bridge$1_0/G_2 RRAM_bridge$1_0/G_1 RRAM_bridge$1_0/TE VSUBS
+ RRAM_bridge$1
XRRAM_bridge$1_1 RRAM_bridge$1_1/Vb_2 RRAM_bridge$1_1/vgnd RRAM_bridge$1_1/DIODE_2
+ RRAM_bridge$1_1/DIODE_1 RRAM_bridge$1_1/Vdd RRAM_bridge$1_1/D_2 RRAM_bridge$1_1/Vb_1
+ RRAM_bridge$1_1/D_1 RRAM_bridge$1_1/G_2 RRAM_bridge$1_1/G_1 RRAM_bridge$1_1/TE VSUBS
+ RRAM_bridge$1
XRRAM_bridge$1_2 RRAM_bridge$1_2/Vb_2 RRAM_bridge$1_2/vgnd RRAM_bridge$1_2/DIODE_2
+ RRAM_bridge$1_2/DIODE_1 RRAM_bridge$1_2/Vdd RRAM_bridge$1_2/D_2 RRAM_bridge$1_2/Vb_1
+ RRAM_bridge$1_2/D_1 RRAM_bridge$1_2/G_2 RRAM_bridge$1_2/G_1 RRAM_bridge$1_2/TE VSUBS
+ RRAM_bridge$1
.ends

.subckt single_RRAM_Array$1
.ends

.subckt X0$1$1$1 a_n5109_n1805# a_n5135_n1747# w_n5257_n1943# a_n5109_n147#
X0 a_n5109_n147# a_n5135_n1747# a_n5109_n1805# w_n5257_n1943# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X4$1$1$1 a_n5074_164# a_n5248_n1596# a_n5074_n1494# a_n5162_n1436#
X0 a_n5074_164# a_n5162_n1436# a_n5074_n1494# a_n5248_n1596# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X7$1$1$1 a_n7416_n4222# a_n7330_n4062# a_n7242_n4120# a_n7242_n2462#
X0 a_n7242_n2462# a_n7330_n4062# a_n7242_n4120# a_n7416_n4222# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X3$1$1$1 a_n5022_n1696# a_n5022_n38# a_n5196_n1798# a_n5110_n1638#
X0 a_n5022_n38# a_n5110_n1638# a_n5022_n1696# a_n5196_n1798# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pad$1$1$1$1$1 single_pad$4$1$1$1$1_0[2|1]/m1_n4000_4006# single_pad$4$1$1$1$1_0[2|0]/m1_n4000_4006#
+ single_pad$4$1$1$1$1_0[1|1]/m1_n4000_4006# single_pad$4$1$1$1$1_0[1|0]/m1_n4000_4006#
+ single_pad$4$1$1$1$1_0[0|1]/m1_n4000_4006# single_pad$4$1$1$1$1_0[0|0]/m1_n4000_4006#
.ends

.subckt X6$1$1$1 a_n7694_n2470# a_n7694_n4128# a_n7868_n4230# a_n7782_n4070#
X0 a_n7694_n2470# a_n7782_n4070# a_n7694_n4128# a_n7868_n4230# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X2$1$1$1 a_n5254_n1836# a_n5168_n1676# a_n5080_n1734# a_n5080_n76#
X0 a_n5080_n76# a_n5168_n1676# a_n5080_n1734# a_n5254_n1836# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X5$1$1$1 a_n5018_n1474# a_n5018_184# a_n5192_n1576# a_n5106_n1416#
X0 a_n5018_184# a_n5106_n1416# a_n5018_n1474# a_n5192_n1576# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt X1$1$1$1 w_n5371_n1923# a_n5223_n127# a_n5223_n1785# a_n5249_n1727#
X0 a_n5223_n127# a_n5249_n1727# a_n5223_n1785# w_n5371_n1923# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pseudo_resistor_s8_6Pins$1 Vdd  Vcontrol1  Vout  Vcontrol2  Vin vgnd
XX0$1$1$1_0 m1_n7863_n1622# m1_n8379_n214# m1_n8466_31# m1_n8466_31# X0$1$1$1
XX4$1$1$1_0 vgnd vgnd m1_n8379_n214#  Vcontrol1 X4$1$1$1
XX7$1$1$1_0 vgnd  Vcontrol2 m1_n8950_n337# vgnd X7$1$1$1
XX3$1$1$1_0 m1_n8949_n1612# m1_n8950_n337# vgnd  Vout X3$1$1$1
Xpad$1$1$1$1$1_0  Vout  Vcontrol1 m1_n8466_31# m1_n8949_n1612# vgnd  Vcontrol2 pad$1$1$1$1$1
XX6$1$1$1_0 vgnd m1_n8950_n337# vgnd  Vcontrol1 X6$1$1$1
XX2$1$1$1_0 vgnd m1_n8466_31# m1_n8949_n1612# m1_n8379_n214# X2$1$1$1
XX5$1$1$1_0 m1_n8379_n214# vgnd vgnd  Vcontrol2 X5$1$1$1
XX1$1$1$1_0  Vout  Vout m1_n7863_n1622# m1_n8950_n337# X1$1$1$1
.ends

.subckt pseudoResistorS8_6PinArray$1 VSUBS
Xpseudo_resistor_s8_6Pins$1_0[0] pseudo_resistor_s8_6Pins$1_0[0]/Vdd pseudo_resistor_s8_6Pins$1_0[0]/ Vcontrol1
+ pseudo_resistor_s8_6Pins$1_0[0]/ Vout pseudo_resistor_s8_6Pins$1_0[0]/ Vcontrol2
+ pseudo_resistor_s8_6Pins$1_0[0]/ Vin VSUBS pseudo_resistor_s8_6Pins$1
Xpseudo_resistor_s8_6Pins$1_0[1] pseudo_resistor_s8_6Pins$1_0[1]/Vdd pseudo_resistor_s8_6Pins$1_0[1]/ Vcontrol1
+ pseudo_resistor_s8_6Pins$1_0[1]/ Vout pseudo_resistor_s8_6Pins$1_0[1]/ Vcontrol2
+ pseudo_resistor_s8_6Pins$1_0[1]/ Vin VSUBS pseudo_resistor_s8_6Pins$1
Xpseudo_resistor_s8_6Pins$1_0[2] pseudo_resistor_s8_6Pins$1_0[2]/Vdd pseudo_resistor_s8_6Pins$1_0[2]/ Vcontrol1
+ pseudo_resistor_s8_6Pins$1_0[2]/ Vout pseudo_resistor_s8_6Pins$1_0[2]/ Vcontrol2
+ pseudo_resistor_s8_6Pins$1_0[2]/ Vin VSUBS pseudo_resistor_s8_6Pins$1
Xpseudo_resistor_s8_6Pins$1_0[3] pseudo_resistor_s8_6Pins$1_0[3]/Vdd pseudo_resistor_s8_6Pins$1_0[3]/ Vcontrol1
+ pseudo_resistor_s8_6Pins$1_0[3]/ Vout pseudo_resistor_s8_6Pins$1_0[3]/ Vcontrol2
+ pseudo_resistor_s8_6Pins$1_0[3]/ Vin VSUBS pseudo_resistor_s8_6Pins$1
.ends

.subckt sky130_fd_pr__pfet_01v8_DJNEY9$1 a_400_n364# w_n596_n584# a_n458_n364# a_n400_n461#
X0 a_400_n364# a_n400_n461# a_n458_n364# w_n596_n584# sky130_fd_pr__pfet_01v8 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=4e+06u
.ends

.subckt pmos_l4u$1 pmos_l4u/a_n458_n364# pmos_l4u/a_400_n364# pmos_l4u/a_n400_n461#
+ pmos_l4u/w_n596_n584#
Xpmos_l4u pmos_l4u/a_400_n364# pmos_l4u/w_n596_n584# pmos_l4u/a_n458_n364# pmos_l4u/a_n400_n461#
+ sky130_fd_pr__pfet_01v8_DJNEY9$1
.ends

.subckt pseudo_resistor_d1$1 Vin Vout Vb
Xpmos_l4u$1_0 Vin m1_186_558# Vb Vin pmos_l4u$1
Xpmos_l4u$1_1 m1_186_558# Vout Vb Vout pmos_l4u$1
.ends

.subckt pseudoResistorD1Array$1
Xpseudo_resistor_d1$1_0[0] pseudo_resistor_d1$1_0[0]/Vin pseudo_resistor_d1$1_0[0]/Vout
+ pseudo_resistor_d1$1_0[0]/Vb pseudo_resistor_d1$1
Xpseudo_resistor_d1$1_0[1] pseudo_resistor_d1$1_0[1]/Vin pseudo_resistor_d1$1_0[1]/Vout
+ pseudo_resistor_d1$1_0[1]/Vb pseudo_resistor_d1$1
Xpseudo_resistor_d1$1_0[2] pseudo_resistor_d1$1_0[2]/Vin pseudo_resistor_d1$1_0[2]/Vout
+ pseudo_resistor_d1$1_0[2]/Vb pseudo_resistor_d1$1
Xpseudo_resistor_d1$1_0[3] pseudo_resistor_d1$1_0[3]/Vin pseudo_resistor_d1$1_0[3]/Vout
+ pseudo_resistor_d1$1_0[3]/Vb pseudo_resistor_d1$1
Xpseudo_resistor_d1$1_0[4] pseudo_resistor_d1$1_0[4]/Vin pseudo_resistor_d1$1_0[4]/Vout
+ pseudo_resistor_d1$1_0[4]/Vb pseudo_resistor_d1$1
.ends

.subckt sky130_fd_pr__pfet_01v8$2 a_800_n78# a_n800_n104# a_n858_n78# w_n996_n226#
X0 a_800_n78# a_n800_n104# a_n858_n78# w_n996_n226# sky130_fd_pr__pfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt pmos_l8u$1$1 pmos/w_n996_n226# pmos/a_n800_n104# pmos/a_800_n78# pmos/a_n858_n78#
Xpmos pmos/a_800_n78# pmos/a_n800_n104# pmos/a_n858_n78# pmos/w_n996_n226# sky130_fd_pr__pfet_01v8$2
.ends

.subckt pad$1$1$1$2 single_pad$4$1$1$2_0[0|0]/m1_n4000_4006# single_pad$4$1$1$2_0[2|1]/m1_n4000_4006#
+ single_pad$4$1$1$2_0[2|0]/m1_n4000_4006# single_pad$4$1$1$2_0[1|1]/m1_n4000_4006#
+ single_pad$4$1$1$2_0[1|0]/m1_n4000_4006# single_pad$4$1$1$2_0[0|1]/m1_n4000_4006#
.ends

.subckt sky130_fd_pr__nfet_01v8_ZZXZ62$1 a_800_n73# a_n800_n99# a_n858_n73# a_n960_n185#
X0 a_800_n73# a_n800_n99# a_n858_n73# a_n960_n185# sky130_fd_pr__nfet_01v8 ad=1.218e+11p pd=1.42e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=8e+06u
.ends

.subckt nmos_l8u$1$1 nmos/a_n858_n73# nmos/a_n800_n99# nmos/a_800_n73# VSUBS
Xnmos nmos/a_800_n73# nmos/a_n800_n99# nmos/a_n858_n73# VSUBS sky130_fd_pr__nfet_01v8_ZZXZ62$1
.ends

.subckt pseudo_resistor_d4$1 Vcontrol1 Vcontrol3 vgnd Vin Vout Vcontrol2 VSUBS
Xpmos_l8u$1$1_0 Vin m1_91_n2147# Vin m1_91_n2147# pmos_l8u$1$1
Xpmos_l8u$1$1_2 Vin m1_91_n1395# m1_1753_n647# Vin pmos_l8u$1$1
Xpmos_l8u$1$1_1 m1_n107_n1055# m1_91_n1395# m1_n107_n1055# m1_91_n1395# pmos_l8u$1$1
Xpmos_l8u$1$1_3 m1_n107_n1055# m1_91_n2147# m1_1753_n647# m1_n107_n1055# pmos_l8u$1$1
Xpad$1$1$1$2_0 VSUBS m1_2677_208# Vin m1_3611_n510# m1_n107_n1055# Vcontrol1 pad$1$1$1$2
Xnmos_l8u$1$1_0 VSUBS Vcontrol1 m1_91_n2147# VSUBS nmos_l8u$1$1
Xnmos_l8u$1$1_2 VSUBS m1_3611_n510# m1_91_n2147# VSUBS nmos_l8u$1$1
Xnmos_l8u$1$1_1 VSUBS Vcontrol1 m1_91_n1395# VSUBS nmos_l8u$1$1
Xnmos_l8u$1$1_3 VSUBS m1_2677_208# m1_91_n2147# VSUBS nmos_l8u$1$1
Xnmos_l8u$1$1_4 VSUBS m1_3611_n510# m1_91_n1395# VSUBS nmos_l8u$1$1
Xnmos_l8u$1$1_5 VSUBS m1_2677_208# m1_91_n1395# VSUBS nmos_l8u$1$1
.ends

.subckt pseudoResistorD4Array$1 VSUBS
Xpseudo_resistor_d4$1_0[0] pseudo_resistor_d4$1_0[0]/Vcontrol1 pseudo_resistor_d4$1_0[0]/Vcontrol3
+ pseudo_resistor_d4$1_0[0]/vgnd pseudo_resistor_d4$1_0[0]/Vin pseudo_resistor_d4$1_0[0]/Vout
+ pseudo_resistor_d4$1_0[0]/Vcontrol2 VSUBS pseudo_resistor_d4$1
Xpseudo_resistor_d4$1_0[1] pseudo_resistor_d4$1_0[1]/Vcontrol1 pseudo_resistor_d4$1_0[1]/Vcontrol3
+ pseudo_resistor_d4$1_0[1]/vgnd pseudo_resistor_d4$1_0[1]/Vin pseudo_resistor_d4$1_0[1]/Vout
+ pseudo_resistor_d4$1_0[1]/Vcontrol2 VSUBS pseudo_resistor_d4$1
Xpseudo_resistor_d4$1_0[2] pseudo_resistor_d4$1_0[2]/Vcontrol1 pseudo_resistor_d4$1_0[2]/Vcontrol3
+ pseudo_resistor_d4$1_0[2]/vgnd pseudo_resistor_d4$1_0[2]/Vin pseudo_resistor_d4$1_0[2]/Vout
+ pseudo_resistor_d4$1_0[2]/Vcontrol2 VSUBS pseudo_resistor_d4$1
Xpseudo_resistor_d4$1_0[3] pseudo_resistor_d4$1_0[3]/Vcontrol1 pseudo_resistor_d4$1_0[3]/Vcontrol3
+ pseudo_resistor_d4$1_0[3]/vgnd pseudo_resistor_d4$1_0[3]/Vin pseudo_resistor_d4$1_0[3]/Vout
+ pseudo_resistor_d4$1_0[3]/Vcontrol2 VSUBS pseudo_resistor_d4$1
.ends

.subckt GWU_Adamlab$1 VSUBS
XpseudoResistorS8Array$1_0 VSUBS pseudoResistorS8Array$1
XsinglePmosArray$1_0 singlePmosArray$1
XsingleNmosArray$1_0 VSUBS singleNmosArray$1
XRRAM_bridgeArray$1_0 VSUBS RRAM_bridgeArray$1
Xsingle_RRAM_Array$1_0 single_RRAM_Array$1
XpseudoResistorS8_6PinArray$1_0 VSUBS pseudoResistorS8_6PinArray$1
XpseudoResistorD1Array$1_0 pseudoResistorD1Array$1
XpseudoResistorD4Array$1_0 VSUBS pseudoResistorD4Array$1
XpseudoResistorD4Array$1_1 VSUBS pseudoResistorD4Array$1
.ends

.subckt nwell$1
.ends

.subckt nfet_01v8$1 pad_forty$6$1_0[1|4]/VSUBS
X0 a_19696_18954# a_18196_17178# a_18138_17266# pad_forty$6$1_0[1|4]/VSUBS sky130_fd_pr__nfet_01v8 ad=2.7e+11p pd=2.54e+06u as=2.32e+12p ps=1.658e+07u w=4.5e+06u l=1.7564e+08u
.ends

.subckt hall_mosfet$1 VSUBS
Xnfet_01v8$1_0 VSUBS nfet_01v8$1
.ends

.subckt ndiff$1
.ends

.subckt sky130_fd_pr__cap_mim_m3_2_5RKW4M$1 m4_n3351_n3100# c2_n3251_n3000#
X0 c2_n3251_n3000# m4_n3351_n3100# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
.ends

.subckt x2fF_decap$1 sky130_fd_pr__cap_mim_m3_2_5RKW4M$1_0/c2_n3251_n3000# sky130_fd_pr__cap_mim_m3_2_5RKW4M$1_0/m4_n3351_n3100#
Xsky130_fd_pr__cap_mim_m3_2_5RKW4M$1_0 sky130_fd_pr__cap_mim_m3_2_5RKW4M$1_0/m4_n3351_n3100#
+ sky130_fd_pr__cap_mim_m3_2_5RKW4M$1_0/c2_n3251_n3000# sky130_fd_pr__cap_mim_m3_2_5RKW4M$1
.ends

.subckt DCDC_INVERTER$1 VNB VPB A Y
X0 VPB A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X1 VNB A Y VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21ai_0$1 VGND VPWR Y B1 A2 A1 VNB VPB
X0 a_120_369# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.536e+11p pd=1.76e+06u as=3.52e+11p ps=3.66e+06u w=640000u l=150000u
X1 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.289e+11p ps=2.77e+06u w=420000u l=150000u
X2 Y A2 a_120_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.792e+11p pd=1.84e+06u as=0p ps=0u w=640000u l=150000u
X3 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=1.113e+11p pd=1.37e+06u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_1$1$1 VGND VPWR Y B A VNB VPB
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=5.2e+11p pd=5.04e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_1$1$1 VGND VPWR Y A VNB VPB
X0 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor2_1$1$1 VGND VPWR B Y A VNB VPB
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21bai_1$1 VPWR VGND A1 Y B1_N A2 VNB VPB
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=2.55e+11p pd=2.51e+06u as=3.05e+11p ps=2.61e+06u w=1e+06u l=150000u
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=2.847e+11p ps=3.2e+06u w=420000u l=150000u
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=3.705e+11p pd=3.74e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=6.365e+11p pd=5.36e+06u as=0p ps=0u w=1e+06u l=150000u
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_2$1$1 VPWR VGND A Y VNB VPB
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=5.2e+11p ps=5.04e+06u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1$1 VPWR VGND A X VNB VPB
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=8.445e+11p ps=7.95e+06u w=1e+06u l=150000u
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=5.82e+11p pd=5.85e+06u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand3_1$1$1 VGND VPWR Y A C B VNB VPB
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=5.9e+11p pd=5.18e+06u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=2.145e+11p pd=1.96e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_2$1$1 VGND VPWR A X VNB VPB
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.85e+11p pd=5.17e+06u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=2.457e+11p pd=2.85e+06u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o22ai_1$1 VGND VPWR A2 B1 Y A1 B2 VNB VPB
X0 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=5.6875e+11p ps=5.65e+06u w=650000u l=150000u
X1 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.8525e+11p ps=1.87e+06u w=650000u l=150000u
X2 VPWR A1 a_307_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.3e+11p pd=5.06e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X3 a_307_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=4.65e+11p ps=2.93e+06u w=1e+06u l=150000u
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.25e+11p ps=2.45e+06u w=1e+06u l=150000u
X6 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_1$1$1 VGND VPWR X A VNB VPB
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=2.291e+11p pd=2.16e+06u as=2.054e+11p ps=2.1e+06u w=790000u l=150000u
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.352e+11p pd=1.56e+06u as=1.508e+11p ps=1.62e+06u w=520000u l=150000u
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.054e+11p pd=2.1e+06u as=0p ps=0u w=790000u l=150000u
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.352e+11p ps=1.56e+06u w=520000u l=150000u
.ends

.subckt sky130_fd_sc_hd__a21oi_1$1 VPWR VGND A1 B1 Y A2 VNB VPB
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=1.9175e+11p pd=1.89e+06u as=1.82e+11p ps=1.86e+06u w=650000u l=150000u
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=5.45e+11p pd=5.09e+06u as=2.95e+11p ps=2.59e+06u w=1e+06u l=150000u
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_2$1$1 VGND VPWR Y A B VNB VPB
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=7.9e+11p pd=7.58e+06u as=5.4e+11p ps=5.08e+06u w=1e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=5.135e+11p pd=5.48e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand4_1$1 VPWR VGND C B Y D A VNB VPB
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=6e+11p pd=5.2e+06u as=8.3e+11p ps=7.66e+06u w=1e+06u l=150000u
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=1.95e+11p pd=1.9e+06u as=2.145e+11p ps=1.96e+06u w=650000u l=150000u
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__o21ai_1$1 VGND VPWR A2 A1 B1 Y VNB VPB
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.48e+11p pd=2.78e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=4.42e+11p pd=4.44e+06u as=0p ps=0u w=700000u l=150000u
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=3.445e+11p pd=3.66e+06u as=2.145e+11p ps=1.96e+06u w=650000u l=150000u
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor3_1$1 VGND VPWR C Y A B VNB VPB
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=3.445e+11p pd=3.66e+06u as=3.445e+11p ps=3.66e+06u w=650000u l=150000u
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkinv_2$1 VPWR VGND Y A VNB VPB
X0 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.205e+11p ps=2.73e+06u w=420000u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=5.45e+11p pd=5.09e+06u as=5.45e+11p ps=5.09e+06u w=1e+06u l=150000u
X2 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__ha_1$1 VGND VPWR B A COUT SUM VNB VPB
X0 a_297_47# a_250_199# a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=2.226e+11p pd=2.74e+06u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X1 a_297_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=4.764e+11p ps=5.15e+06u w=420000u l=150000u
X2 COUT a_250_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=1.0518e+12p ps=8.44e+06u w=1e+06u l=150000u
X3 a_250_199# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.218e+11p pd=1.42e+06u as=0p ps=0u w=420000u l=150000u
X4 a_376_413# B a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.68e+11p pd=1.64e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X5 a_79_21# a_250_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 a_674_47# B a_250_199# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X7 VPWR A a_376_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 COUT a_250_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X10 VPWR a_79_21# SUM VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X11 VPWR A a_250_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 VGND A a_674_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 VGND a_79_21# SUM VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__xor2_1$1 VPWR VGND B X A VNB VPB
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=3e+11p pd=2.6e+06u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=5.005e+11p pd=2.84e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=5.525e+11p ps=5.6e+06u w=650000u l=150000u
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.3e+11p pd=5.06e+06u as=0p ps=0u w=1e+06u l=150000u
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt dcdc_config$1 VPWR a[0] a[1] a[2] a[3] a[4] a[5] s[0] s[10] s[11] s[1] s[2]
+ s[3] s[4] s[5] s[6] s[7] s[8] s[9] VGND
Xsky130_fd_sc_hd__o21ai_0$1_2 VGND VPWR sky130_fd_sc_hd__o21ai_0$1_2/Y sky130_fd_sc_hd__o21ai_0$1_2/B1
+ sky130_fd_sc_hd__o21ai_0$1_2/A2 sky130_fd_sc_hd__o21ai_0$1_2/A1 VGND VPWR sky130_fd_sc_hd__o21ai_0$1
Xsky130_fd_sc_hd__nand2_1$1$1_15 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1_16/B sky130_fd_sc_hd__inv_1$1$1_10/Y
+ sky130_fd_sc_hd__clkinv_2$1_1/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_16 VGND VPWR sky130_fd_sc_hd__ha_1$1_0/A sky130_fd_sc_hd__nand2_1$1$1_16/B
+ sky130_fd_sc_hd__nand3_1$1$1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_17 VGND VPWR sky130_fd_sc_hd__nand3_1$1$1_3/B sky130_fd_sc_hd__o21ai_0$1_1/A2
+ sky130_fd_sc_hd__nand3_1$1$1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_18 VGND VPWR sky130_fd_sc_hd__nand4_1$1_0/A sky130_fd_sc_hd__o21ai_0$1_1/A2
+ sky130_fd_sc_hd__nand2_1$1$1_19/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__inv_1$1$1_10 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_10/Y sky130_fd_sc_hd__o21ai_0$1_1/A2
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_19 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1_19/Y sky130_fd_sc_hd__o22ai_1$1_0/A2
+ sky130_fd_sc_hd__nand2_1$1$1_20/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nor2_1$1$1_0 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_3/A sky130_fd_sc_hd__nor3_1$1_1/B
+ sky130_fd_sc_hd__o21ai_0$1_1/A2 VGND VPWR sky130_fd_sc_hd__nor2_1$1$1
Xsky130_fd_sc_hd__o21bai_1$1_0 VPWR VGND sky130_fd_sc_hd__nor3_1$1_1/A sky130_fd_sc_hd__o21bai_1$1_0/Y
+ sky130_fd_sc_hd__ha_1$1_0/B sky130_fd_sc_hd__o22ai_1$1_0/B2 VGND VPWR sky130_fd_sc_hd__o21bai_1$1
Xsky130_fd_sc_hd__inv_2$1$1_0 VPWR VGND sky130_fd_sc_hd__ha_1$1_0/A sky130_fd_sc_hd__nor3_1$1_1/C
+ VGND VPWR sky130_fd_sc_hd__inv_2$1$1
Xsky130_fd_sc_hd__dlymetal6s2s_1$1_0 VPWR VGND a[2] sky130_fd_sc_hd__inv_1$1$1_3/A
+ VGND VPWR sky130_fd_sc_hd__dlymetal6s2s_1$1
Xsky130_fd_sc_hd__inv_1$1$1_0 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_0/Y sky130_fd_sc_hd__xor2_1$1_0/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__inv_1$1$1_1 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_1/Y sky130_fd_sc_hd__inv_1$1$1_1/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__nand3_1$1$1_0 VGND VPWR sky130_fd_sc_hd__nand3_1$1$1_0/Y sky130_fd_sc_hd__o22ai_1$1_0/B2
+ sky130_fd_sc_hd__nand3_1$1$1_1/Y sky130_fd_sc_hd__nand3_1$1$1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$1$1
Xsky130_fd_sc_hd__clkbuf_2$1$1_0 VGND VPWR a[3] sky130_fd_sc_hd__xor2_1$1_0/B VGND
+ VPWR sky130_fd_sc_hd__clkbuf_2$1$1
Xsky130_fd_sc_hd__o22ai_1$1_0 VGND VPWR sky130_fd_sc_hd__o22ai_1$1_0/A2 sky130_fd_sc_hd__inv_1$1$1_3/A
+ sky130_fd_sc_hd__o22ai_1$1_0/Y sky130_fd_sc_hd__xor2_1$1_0/B sky130_fd_sc_hd__o22ai_1$1_0/B2
+ VGND VPWR sky130_fd_sc_hd__o22ai_1$1
Xsky130_fd_sc_hd__inv_1$1$1_2 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_2/Y sky130_fd_sc_hd__o22ai_1$1_0/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__nand3_1$1$1_1 VGND VPWR sky130_fd_sc_hd__nand3_1$1$1_1/Y sky130_fd_sc_hd__o21ai_0$1_0/Y
+ sky130_fd_sc_hd__nand3_1$1$1_1/C sky130_fd_sc_hd__nor3_1$1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$1$1
Xsky130_fd_sc_hd__clkbuf_2$1$1_1 VGND VPWR a[4] sky130_fd_sc_hd__o21ai_0$1_1/A2 VGND
+ VPWR sky130_fd_sc_hd__clkbuf_2$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_0 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_1/A a[1] VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__inv_1$1$1_3 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_3/Y sky130_fd_sc_hd__inv_1$1$1_3/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__nand3_1$1$1_2 VGND VPWR sky130_fd_sc_hd__nand4_1$1_0/B sky130_fd_sc_hd__o21ai_0$1_1/Y
+ sky130_fd_sc_hd__o22ai_1$1_0/A2 sky130_fd_sc_hd__xor2_1$1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$1$1
Xsky130_fd_sc_hd__clkbuf_2$1$1_2 VGND VPWR a[5] sky130_fd_sc_hd__nor3_1$1_0/B VGND
+ VPWR sky130_fd_sc_hd__clkbuf_2$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_1 VGND VPWR sky130_fd_sc_hd__xor2_1$1_0/A a[0] VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__inv_1$1$1_4 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_4/Y sky130_fd_sc_hd__inv_1$1$1_4/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__nand3_1$1$1_3 VGND VPWR sky130_fd_sc_hd__a21oi_1$1_1/A1 sky130_fd_sc_hd__inv_1$1$1_9/Y
+ sky130_fd_sc_hd__o22ai_1$1_0/B2 sky130_fd_sc_hd__nand3_1$1$1_3/B VGND VPWR sky130_fd_sc_hd__nand3_1$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_2 VGND VPWR s[6] sky130_fd_sc_hd__o21ai_1$1_0/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__inv_1$1$1_5 VGND VPWR sky130_fd_sc_hd__nor3_1$1_1/A sky130_fd_sc_hd__nor3_1$1_0/B
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__nand3_1$1$1_4 VGND VPWR sky130_fd_sc_hd__nand3_1$1$1_5/C sky130_fd_sc_hd__nor3_1$1_1/C
+ sky130_fd_sc_hd__inv_1$1$1_9/Y sky130_fd_sc_hd__nor3_1$1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_3 VGND VPWR s[7] sky130_fd_sc_hd__o21bai_1$1_0/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__inv_1$1$1_6 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_6/Y sky130_fd_sc_hd__ha_1$1_0/SUM
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__nand3_1$1$1_5 VGND VPWR sky130_fd_sc_hd__nand3_1$1$1_5/Y sky130_fd_sc_hd__nand4_1$1_0/A
+ sky130_fd_sc_hd__nand3_1$1$1_5/C sky130_fd_sc_hd__nand4_1$1_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_4 VGND VPWR s[8] sky130_fd_sc_hd__clkinv_2$1_1/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__inv_1$1$1_7 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_7/Y sky130_fd_sc_hd__inv_1$1$1_7/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__a21oi_1$1_0 VPWR VGND sky130_fd_sc_hd__a21oi_1$1_0/A1 sky130_fd_sc_hd__o21ai_1$1_0/Y
+ sky130_fd_sc_hd__ha_1$1_0/B sky130_fd_sc_hd__a21oi_1$1_0/A2 VGND VPWR sky130_fd_sc_hd__a21oi_1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_5 VGND VPWR s[9] sky130_fd_sc_hd__nand2_1$1$1_10/Y
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__inv_1$1$1_8 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_8/Y sky130_fd_sc_hd__inv_1$1$1_8/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__a21oi_1$1_1 VPWR VGND sky130_fd_sc_hd__a21oi_1$1_1/A1 sky130_fd_sc_hd__nor3_1$1_1/Y
+ sky130_fd_sc_hd__inv_1$1$1_7/A sky130_fd_sc_hd__inv_1$1$1_2/Y VGND VPWR sky130_fd_sc_hd__a21oi_1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_10 VGND VPWR s[3] sky130_fd_sc_hd__nand2_1$1$1_12/Y
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_6 VGND VPWR s[11] sky130_fd_sc_hd__inv_1$1$1_4/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__inv_1$1$1_9 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_9/Y sky130_fd_sc_hd__o21ai_1$1_0/Y
+ VGND VPWR sky130_fd_sc_hd__inv_1$1$1
Xsky130_fd_sc_hd__nand2_2$1$1_0 VGND VPWR sky130_fd_sc_hd__o22ai_1$1_0/B2 sky130_fd_sc_hd__o21ai_0$1_2/Y
+ sky130_fd_sc_hd__nor3_1$1_0/C VGND VPWR sky130_fd_sc_hd__nand2_2$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_11 VGND VPWR s[4] sky130_fd_sc_hd__nor3_1$1_1/C VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_7 VGND VPWR s[10] sky130_fd_sc_hd__inv_1$1$1_4/A VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_12 VGND VPWR s[0] sky130_fd_sc_hd__nand2_1$1$1_13/Y
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_0 VGND VPWR sky130_fd_sc_hd__nor3_1$1_0/C sky130_fd_sc_hd__inv_1$1$1_0/Y
+ sky130_fd_sc_hd__inv_1$1$1_1/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_8 VGND VPWR s[1] sky130_fd_sc_hd__inv_1$1$1_7/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__nand4_1$1_0 VPWR VGND sky130_fd_sc_hd__ha_1$1_0/A sky130_fd_sc_hd__nand4_1$1_0/B
+ sky130_fd_sc_hd__nand4_1$1_0/Y sky130_fd_sc_hd__ha_1$1_0/B sky130_fd_sc_hd__nand4_1$1_0/A
+ VGND VPWR sky130_fd_sc_hd__nand4_1$1
Xsky130_fd_sc_hd__o21ai_1$1_0 VGND VPWR sky130_fd_sc_hd__o22ai_1$1_0/B2 sky130_fd_sc_hd__nor3_1$1_1/A
+ sky130_fd_sc_hd__o22ai_1$1_0/A2 sky130_fd_sc_hd__o21ai_1$1_0/Y VGND VPWR sky130_fd_sc_hd__o21ai_1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_13 VGND VPWR s[5] sky130_fd_sc_hd__inv_1$1$1_6/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_1 VGND VPWR sky130_fd_sc_hd__o22ai_1$1_0/A2 sky130_fd_sc_hd__nand3_1$1$1_1/C
+ sky130_fd_sc_hd__o21ai_0$1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__clkbuf_1$1$1_9 VGND VPWR s[2] sky130_fd_sc_hd__nand3_1$1$1_5/Y VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$1$1
Xsky130_fd_sc_hd__nor3_1$1_0 VGND VPWR sky130_fd_sc_hd__nor3_1$1_0/C sky130_fd_sc_hd__nor3_1$1_0/Y
+ sky130_fd_sc_hd__xor2_1$1_0/B sky130_fd_sc_hd__nor3_1$1_0/B VGND VPWR sky130_fd_sc_hd__nor3_1$1
Xsky130_fd_sc_hd__nand2_1$1$1_2 VGND VPWR sky130_fd_sc_hd__nand3_1$1$1_0/B sky130_fd_sc_hd__xor2_1$1_0/X
+ sky130_fd_sc_hd__o22ai_1$1_0/A2 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__clkinv_2$1_0 VPWR VGND sky130_fd_sc_hd__o21ai_0$1_2/B1 sky130_fd_sc_hd__clkinv_2$1_0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_2$1
Xsky130_fd_sc_hd__nor3_1$1_1 VGND VPWR sky130_fd_sc_hd__nor3_1$1_1/C sky130_fd_sc_hd__nor3_1$1_1/Y
+ sky130_fd_sc_hd__nor3_1$1_1/A sky130_fd_sc_hd__nor3_1$1_1/B VGND VPWR sky130_fd_sc_hd__nor3_1$1
Xsky130_fd_sc_hd__nand2_1$1$1_3 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1_8/B sky130_fd_sc_hd__nor3_1$1_1/B
+ sky130_fd_sc_hd__nor3_1$1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__ha_1$1_0 VGND VPWR sky130_fd_sc_hd__ha_1$1_0/B sky130_fd_sc_hd__ha_1$1_0/A
+ sky130_fd_sc_hd__inv_1$1$1_8/A sky130_fd_sc_hd__ha_1$1_0/SUM VGND VPWR sky130_fd_sc_hd__ha_1$1
Xsky130_fd_sc_hd__xor2_1$1_0 VPWR VGND sky130_fd_sc_hd__xor2_1$1_0/B sky130_fd_sc_hd__xor2_1$1_0/X
+ sky130_fd_sc_hd__xor2_1$1_0/A VGND VPWR sky130_fd_sc_hd__xor2_1$1
Xsky130_fd_sc_hd__clkinv_2$1_1 VPWR VGND sky130_fd_sc_hd__clkinv_2$1_1/Y sky130_fd_sc_hd__o22ai_1$1_0/B2
+ VGND VPWR sky130_fd_sc_hd__clkinv_2$1
Xsky130_fd_sc_hd__nand2_1$1$1_4 VGND VPWR sky130_fd_sc_hd__o21ai_0$1_2/A1 sky130_fd_sc_hd__nor3_1$1_0/B
+ sky130_fd_sc_hd__o21ai_0$1_1/A2 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_5 VGND VPWR sky130_fd_sc_hd__nand3_1$1$1_1/C sky130_fd_sc_hd__inv_1$1$1_3/Y
+ sky130_fd_sc_hd__clkinv_2$1_0/A VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_6 VGND VPWR sky130_fd_sc_hd__o21ai_0$1_2/A2 sky130_fd_sc_hd__inv_1$1$1_3/A
+ sky130_fd_sc_hd__xor2_1$1_0/B VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_7 VGND VPWR sky130_fd_sc_hd__a21oi_1$1_0/A2 sky130_fd_sc_hd__o22ai_1$1_0/B2
+ sky130_fd_sc_hd__nand2_1$1$1_8/B VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_20 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1_20/Y sky130_fd_sc_hd__inv_1$1$1_1/Y
+ sky130_fd_sc_hd__ha_1$1_0/A VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_8 VGND VPWR sky130_fd_sc_hd__inv_1$1$1_4/A sky130_fd_sc_hd__nand2_1$1$1_8/B
+ sky130_fd_sc_hd__a21oi_1$1_0/A1 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_10 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1_10/Y sky130_fd_sc_hd__a21oi_1$1_0/A2
+ sky130_fd_sc_hd__a21oi_1$1_0/A1 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_9 VGND VPWR sky130_fd_sc_hd__a21oi_1$1_0/A1 sky130_fd_sc_hd__o21ai_0$1_2/B1
+ sky130_fd_sc_hd__clkinv_2$1_1/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_11 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1_12/A sky130_fd_sc_hd__inv_1$1$1_8/Y
+ sky130_fd_sc_hd__nand3_1$1$1_5/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_12 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1_12/Y sky130_fd_sc_hd__nand4_1$1_0/Y
+ sky130_fd_sc_hd__nand2_1$1$1_12/A VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__nand2_1$1$1_13 VGND VPWR sky130_fd_sc_hd__nand2_1$1$1_13/Y sky130_fd_sc_hd__inv_1$1$1_7/A
+ sky130_fd_sc_hd__nand4_1$1_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
Xsky130_fd_sc_hd__o21ai_0$1_0 VGND VPWR sky130_fd_sc_hd__o21ai_0$1_0/Y sky130_fd_sc_hd__inv_1$1$1_3/A
+ sky130_fd_sc_hd__xor2_1$1_0/A sky130_fd_sc_hd__inv_1$1$1_1/A VGND VPWR sky130_fd_sc_hd__o21ai_0$1
Xsky130_fd_sc_hd__o21ai_0$1_1 VGND VPWR sky130_fd_sc_hd__o21ai_0$1_1/Y sky130_fd_sc_hd__o22ai_1$1_0/B2
+ sky130_fd_sc_hd__o21ai_0$1_1/A2 sky130_fd_sc_hd__inv_1$1$1_0/Y VGND VPWR sky130_fd_sc_hd__o21ai_0$1
Xsky130_fd_sc_hd__nand2_1$1$1_14 VGND VPWR sky130_fd_sc_hd__clkinv_2$1_0/A sky130_fd_sc_hd__xor2_1$1_0/A
+ sky130_fd_sc_hd__inv_1$1$1_1/A VGND VPWR sky130_fd_sc_hd__nand2_1$1$1
.ends

.subckt sky130_fd_sc_hd__dfstp_1$1 VPWR VGND D Q SET_B CLK VNB VPB
X0 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=9.868e+11p pd=1.019e+07u as=1.341e+11p ps=1.5e+06u w=420000u l=150000u
X1 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=9.66e+10p pd=1.3e+06u as=1.3171e+12p ps=1.335e+07u w=420000u l=150000u
X2 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X3 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.44e+11p ps=1.52e+06u w=360000u l=150000u
X4 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X5 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.87e+11p ps=1.93e+06u w=360000u l=150000u
X6 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X7 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.499e+11p pd=2.35e+06u as=0p ps=0u w=840000u l=150000u
X8 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_1224_47# a_27_47# a_1032_413# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=1.386e+11p ps=1.5e+06u w=420000u l=150000u
X10 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.89e+11p pd=1.74e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X11 VGND a_1032_413# a_1602_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X12 VPWR a_1182_261# a_1140_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=8.82e+10p ps=1.26e+06u w=420000u l=150000u
X13 Q a_1602_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X14 a_1032_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X16 a_1296_47# a_1182_261# a_1224_47# VNB sky130_fd_pr__nfet_01v8 ad=9.66e+10p pd=1.3e+06u as=0p ps=0u w=420000u l=150000u
X17 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X18 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X19 VPWR SET_B a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.73e+11p ps=2.98e+06u w=420000u l=150000u
X20 a_1032_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 a_1182_261# a_1032_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.184e+11p pd=2.2e+06u as=0p ps=0u w=840000u l=150000u
X22 Q a_1602_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X24 a_1140_413# a_193_47# a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 VPWR a_1032_413# a_1602_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X26 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X27 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X28 a_1182_261# a_1032_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.404e+11p pd=1.6e+06u as=0p ps=0u w=540000u l=150000u
X29 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X30 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X31 VGND SET_B a_1296_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_2$2 VPWR VGND A Y VNB VPB
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=5.2e+11p ps=5.04e+06u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_1$2 VGND VPWR X A VNB VPB
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=2.291e+11p pd=2.16e+06u as=2.054e+11p ps=2.1e+06u w=790000u l=150000u
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.352e+11p pd=1.56e+06u as=1.508e+11p ps=1.62e+06u w=520000u l=150000u
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.054e+11p pd=2.1e+06u as=0p ps=0u w=790000u l=150000u
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.352e+11p ps=1.56e+06u w=520000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand3_1$2 VGND VPWR Y A C B VNB VPB
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=5.9e+11p pd=5.18e+06u as=5.3e+11p ps=5.06e+06u w=1e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=2.145e+11p pd=1.96e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_1$2 VGND VPWR Y B A VNB VPB
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=5.2e+11p pd=5.04e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__nor2_1$2 VGND VPWR B Y A VNB VPB
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.1e+11p ps=2.42e+06u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_2$1 VPWR VGND X A VNB VPB
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=5.63e+11p pd=5.18e+06u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=3.6625e+11p ps=3.78e+06u w=650000u l=150000u
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_1$2 VGND VPWR Y A VNB VPB
X0 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1$1 VPWR VGND A X VNB VPB
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=3.139e+11p ps=3.35e+06u w=650000u l=150000u
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=3.949e+11p pd=4.03e+06u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_16$1 VGND VPWR A X VNB VPB
X0 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=2.093e+12p pd=2.204e+07u as=5.265e+11p ps=5.52e+06u w=650000u l=150000u
X1 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.16e+12p pd=2.032e+07u as=3.22e+12p ps=3.044e+07u w=1e+06u l=150000u
X2 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.404e+12p ps=1.472e+07u w=650000u l=150000u
X3 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=8.1e+11p pd=7.62e+06u as=0p ps=0u w=1e+06u l=150000u
X8 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X11 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X13 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X14 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X15 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X21 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X25 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X26 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X27 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X28 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X31 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X32 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X33 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X34 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X35 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X36 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X37 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X38 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X39 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X40 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X41 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X42 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X43 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_4$1 VGND VPWR X A VNB VPB
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=9.1e+11p pd=7.82e+06u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=3.801e+11p pd=4.33e+06u as=2.352e+11p ps=2.8e+06u w=420000u l=150000u
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=5.6e+11p pd=5.12e+06u as=0p ps=0u w=1e+06u l=150000u
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfstp_2$1 VPWR VGND Q D SET_B CLK VNB VPB
X0 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=1.1373e+12p pd=1.19e+07u as=1.341e+11p ps=1.5e+06u w=420000u l=150000u
X1 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=1.5449e+12p ps=1.575e+07u w=420000u l=150000u
X2 a_1136_413# a_193_47# a_1028_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=2.73e+11p ps=2.98e+06u w=420000u l=150000u
X3 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X4 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.44e+11p ps=1.52e+06u w=360000u l=150000u
X5 a_1228_47# a_27_47# a_1028_413# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=1.47e+11p ps=1.54e+06u w=420000u l=150000u
X6 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X7 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.87e+11p ps=1.93e+06u w=360000u l=150000u
X8 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X9 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.499e+11p pd=2.35e+06u as=0p ps=0u w=840000u l=150000u
X10 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 VPWR a_1602_47# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X12 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.89e+11p pd=1.74e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X13 VGND a_1028_413# a_1602_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X14 VGND a_1602_47# Q VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X15 Q a_1602_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 a_1028_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X19 VPWR a_1028_413# a_1602_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X20 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 Q a_1602_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X22 a_1028_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 VPWR a_1178_261# a_1136_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X25 a_1178_261# a_1028_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.226e+11p pd=2.21e+06u as=0p ps=0u w=840000u l=150000u
X26 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X27 a_1300_47# a_1178_261# a_1228_47# VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X28 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X29 a_1178_261# a_1028_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.404e+11p pd=1.6e+06u as=0p ps=0u w=540000u l=150000u
X30 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X31 VPWR SET_B a_1028_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X32 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X33 VGND SET_B a_1300_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_2$2 VGND VPWR A X VNB VPB
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.85e+11p pd=5.17e+06u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=2.457e+11p pd=2.85e+06u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__nand2_2$2 VGND VPWR Y A B VNB VPB
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=7.9e+11p pd=7.58e+06u as=5.4e+11p ps=5.08e+06u w=1e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=5.135e+11p pd=5.48e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt NON_CLK_GEN$1 clk clk_in clk0 clk0b clk1 clk1b control rst_n VPWR VGND
Xsky130_fd_sc_hd__dfstp_1$1_0 VPWR VGND sky130_fd_sc_hd__dfstp_1$1_5/Q sky130_fd_sc_hd__dfstp_1$1_1/D
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_1/X VGND VPWR sky130_fd_sc_hd__dfstp_1$1
Xsky130_fd_sc_hd__inv_2$2_0 VPWR VGND sky130_fd_sc_hd__inv_2$2_0/A sky130_fd_sc_hd__inv_2$2_0/Y
+ VGND VPWR sky130_fd_sc_hd__inv_2$2
Xsky130_fd_sc_hd__dfstp_1$1_1 VPWR VGND sky130_fd_sc_hd__dfstp_1$1_1/D sky130_fd_sc_hd__inv_1$2_1/A
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_1/X VGND VPWR sky130_fd_sc_hd__dfstp_1$1
Xsky130_fd_sc_hd__dfstp_1$1_2 VPWR VGND sky130_fd_sc_hd__dfstp_1$1_9/Q sky130_fd_sc_hd__dfstp_1$1_5/D
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_1/X VGND VPWR sky130_fd_sc_hd__dfstp_1$1
Xsky130_fd_sc_hd__clkbuf_1$2_0 VGND VPWR sky130_fd_sc_hd__inv_1$2_2/A control VGND
+ VPWR sky130_fd_sc_hd__clkbuf_1$2
Xsky130_fd_sc_hd__dfstp_1$1_3 VPWR VGND sky130_fd_sc_hd__dfstp_1$1_8/Q sky130_fd_sc_hd__dfstp_1$1_6/D
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_2/X VGND VPWR sky130_fd_sc_hd__dfstp_1$1
Xsky130_fd_sc_hd__dfstp_1$1_4 VPWR VGND sky130_fd_sc_hd__inv_1$2_5/A sky130_fd_sc_hd__inv_1$2_3/A
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_2/X VGND VPWR sky130_fd_sc_hd__dfstp_1$1
Xsky130_fd_sc_hd__nand3_1$2_0 VGND VPWR sky130_fd_sc_hd__nand3_1$2_0/Y sky130_fd_sc_hd__nand3_1$2_0/A
+ sky130_fd_sc_hd__inv_1$2_2/A sky130_fd_sc_hd__nand3_1$2_0/B VGND VPWR sky130_fd_sc_hd__nand3_1$2
Xsky130_fd_sc_hd__dfstp_1$1_5 VPWR VGND sky130_fd_sc_hd__dfstp_1$1_5/D sky130_fd_sc_hd__dfstp_1$1_5/Q
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_1/X VGND VPWR sky130_fd_sc_hd__dfstp_1$1
Xsky130_fd_sc_hd__nand3_1$2_1 VGND VPWR sky130_fd_sc_hd__nand3_1$2_1/Y sky130_fd_sc_hd__nand3_1$2_1/A
+ sky130_fd_sc_hd__inv_1$2_3/A sky130_fd_sc_hd__nand3_1$2_1/B VGND VPWR sky130_fd_sc_hd__nand3_1$2
Xsky130_fd_sc_hd__nand2_1$2_0 VGND VPWR sky130_fd_sc_hd__nand2_1$2_0/Y sky130_fd_sc_hd__nand3_1$2_0/B
+ sky130_fd_sc_hd__nand3_1$2_0/A VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__nor2_1$2_0 VGND VPWR sky130_fd_sc_hd__inv_1$2_9/A sky130_fd_sc_hd__nor2_1$2_0/Y
+ sky130_fd_sc_hd__inv_1$2_7/A VGND VPWR sky130_fd_sc_hd__nor2_1$2
Xsky130_fd_sc_hd__dfstp_1$1_6 VPWR VGND sky130_fd_sc_hd__dfstp_1$1_6/D sky130_fd_sc_hd__inv_1$2_5/A
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_2/X VGND VPWR sky130_fd_sc_hd__dfstp_1$1
Xsky130_fd_sc_hd__nand3_1$2_2 VGND VPWR sky130_fd_sc_hd__nand3_1$2_2/Y sky130_fd_sc_hd__nand3_1$2_2/A
+ sky130_fd_sc_hd__inv_1$2_10/Y sky130_fd_sc_hd__nand3_1$2_2/B VGND VPWR sky130_fd_sc_hd__nand3_1$2
Xsky130_fd_sc_hd__buf_2$1_0 VPWR VGND sky130_fd_sc_hd__buf_2$1_0/X sky130_fd_sc_hd__inv_1$2_0/A
+ VGND VPWR sky130_fd_sc_hd__buf_2$1
Xsky130_fd_sc_hd__nand2_1$2_1 VGND VPWR sky130_fd_sc_hd__nand2_1$2_3/A sky130_fd_sc_hd__inv_1$2_0/A
+ sky130_fd_sc_hd__inv_1$2_3/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__dfstp_1$1_7 VPWR VGND sky130_fd_sc_hd__nand2_1$2_3/Y sky130_fd_sc_hd__dfstp_1$1_8/D
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_2/X VGND VPWR sky130_fd_sc_hd__dfstp_1$1
Xsky130_fd_sc_hd__nand2_1$2_2 VGND VPWR sky130_fd_sc_hd__nand2_1$2_3/B sky130_fd_sc_hd__inv_1$2_3/A
+ sky130_fd_sc_hd__inv_1$2_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__dfstp_1$1_8 VPWR VGND sky130_fd_sc_hd__dfstp_1$1_8/D sky130_fd_sc_hd__dfstp_1$1_8/Q
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_2/X VGND VPWR sky130_fd_sc_hd__dfstp_1$1
Xsky130_fd_sc_hd__nand2_1$2_3 VGND VPWR sky130_fd_sc_hd__nand2_1$2_3/Y sky130_fd_sc_hd__nand2_1$2_3/B
+ sky130_fd_sc_hd__nand2_1$2_3/A VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__dfstp_1$1_9 VPWR VGND sky130_fd_sc_hd__dfstp_1$1_9/D sky130_fd_sc_hd__dfstp_1$1_9/Q
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_1/X VGND VPWR sky130_fd_sc_hd__dfstp_1$1
Xsky130_fd_sc_hd__nand2_1$2_4 VGND VPWR sky130_fd_sc_hd__nand3_1$2_0/B sky130_fd_sc_hd__inv_1$2_4/A
+ sky130_fd_sc_hd__inv_1$2_1/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__nand2_1$2_5 VGND VPWR sky130_fd_sc_hd__nand3_1$2_0/A sky130_fd_sc_hd__inv_1$2_1/A
+ sky130_fd_sc_hd__inv_1$2_4/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__nand2_1$2_6 VGND VPWR sky130_fd_sc_hd__buf_16$1_0/A sky130_fd_sc_hd__inv_1$2_6/Y
+ sky130_fd_sc_hd__inv_1$2_7/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__inv_1$2_0 VGND VPWR sky130_fd_sc_hd__inv_1$2_0/Y sky130_fd_sc_hd__inv_1$2_0/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__nand2_1$2_10 VGND VPWR sky130_fd_sc_hd__nand3_1$2_1/B sky130_fd_sc_hd__inv_1$2_5/A
+ sky130_fd_sc_hd__inv_1$2_12/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__nand2_1$2_7 VGND VPWR sky130_fd_sc_hd__nand3_1$2_1/A sky130_fd_sc_hd__inv_1$2_9/Y
+ sky130_fd_sc_hd__inv_1$2_5/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__inv_1$2_1 VGND VPWR sky130_fd_sc_hd__inv_1$2_1/Y sky130_fd_sc_hd__inv_1$2_1/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__nand2_1$2_11 VGND VPWR sky130_fd_sc_hd__nand2_2$2_0/A sky130_fd_sc_hd__inv_1$2_2/Y
+ sky130_fd_sc_hd__nand2_1$2_0/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__nand2_1$2_8 VGND VPWR sky130_fd_sc_hd__inv_1$2_7/A sky130_fd_sc_hd__nand3_1$2_1/Y
+ sky130_fd_sc_hd__nand3_1$2_2/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__dlygate4sd1_1$1_0 VPWR VGND sky130_fd_sc_hd__inv_1$2_4/A sky130_fd_sc_hd__dfstp_1$1_9/D
+ VGND VPWR sky130_fd_sc_hd__dlygate4sd1_1$1
Xsky130_fd_sc_hd__inv_1$2_2 VGND VPWR sky130_fd_sc_hd__inv_1$2_2/Y sky130_fd_sc_hd__inv_1$2_2/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__nand2_1$2_12 VGND VPWR sky130_fd_sc_hd__nand3_1$2_2/A sky130_fd_sc_hd__inv_1$2_5/Y
+ sky130_fd_sc_hd__inv_1$2_11/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__nand2_1$2_9 VGND VPWR sky130_fd_sc_hd__nand3_1$2_2/B sky130_fd_sc_hd__inv_1$2_5/A
+ sky130_fd_sc_hd__inv_1$2_8/Y VGND VPWR sky130_fd_sc_hd__nand2_1$2
Xsky130_fd_sc_hd__inv_1$2_3 VGND VPWR sky130_fd_sc_hd__inv_1$2_3/Y sky130_fd_sc_hd__inv_1$2_3/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__inv_1$2_4 VGND VPWR sky130_fd_sc_hd__inv_1$2_4/Y sky130_fd_sc_hd__inv_1$2_4/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__inv_1$2_5 VGND VPWR sky130_fd_sc_hd__inv_1$2_5/Y sky130_fd_sc_hd__inv_1$2_5/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__inv_1$2_6 VGND VPWR sky130_fd_sc_hd__inv_1$2_6/Y sky130_fd_sc_hd__inv_1$2_9/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__inv_1$2_7 VGND VPWR sky130_fd_sc_hd__inv_1$2_7/Y sky130_fd_sc_hd__inv_1$2_7/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__inv_1$2_8 VGND VPWR sky130_fd_sc_hd__inv_1$2_8/Y sky130_fd_sc_hd__inv_1$2_9/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__inv_1$2_9 VGND VPWR sky130_fd_sc_hd__inv_1$2_9/Y sky130_fd_sc_hd__inv_1$2_9/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__buf_16$1_0 VGND VPWR sky130_fd_sc_hd__buf_16$1_0/A clk1b VGND VPWR
+ sky130_fd_sc_hd__buf_16$1
Xsky130_fd_sc_hd__clkbuf_4$1_0 VGND VPWR sky130_fd_sc_hd__clkbuf_4$1_0/X rst_n VGND
+ VPWR sky130_fd_sc_hd__clkbuf_4$1
Xsky130_fd_sc_hd__dfstp_2$1_0 VPWR VGND sky130_fd_sc_hd__inv_1$2_4/A sky130_fd_sc_hd__buf_2$1_0/X
+ sky130_fd_sc_hd__clkbuf_4$1_0/X sky130_fd_sc_hd__clkbuf_4$1_1/X VGND VPWR sky130_fd_sc_hd__dfstp_2$1
Xsky130_fd_sc_hd__buf_16$1_1 VGND VPWR sky130_fd_sc_hd__inv_2$2_0/Y clk0 VGND VPWR
+ sky130_fd_sc_hd__buf_16$1
Xsky130_fd_sc_hd__clkbuf_4$1_1 VGND VPWR sky130_fd_sc_hd__clkbuf_4$1_1/X sky130_fd_sc_hd__clkbuf_4$1_3/X
+ VGND VPWR sky130_fd_sc_hd__clkbuf_4$1
Xsky130_fd_sc_hd__buf_16$1_2 VGND VPWR sky130_fd_sc_hd__nor2_1$2_0/Y clk1 VGND VPWR
+ sky130_fd_sc_hd__buf_16$1
Xsky130_fd_sc_hd__clkbuf_4$1_2 VGND VPWR sky130_fd_sc_hd__clkbuf_4$1_2/X sky130_fd_sc_hd__clkbuf_4$1_3/X
+ VGND VPWR sky130_fd_sc_hd__clkbuf_4$1
Xsky130_fd_sc_hd__inv_1$2_10 VGND VPWR sky130_fd_sc_hd__inv_1$2_10/Y sky130_fd_sc_hd__inv_1$2_3/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__clkbuf_2$2_0 VGND VPWR clk_in sky130_fd_sc_hd__inv_1$2_9/A VGND
+ VPWR sky130_fd_sc_hd__clkbuf_2$2
Xsky130_fd_sc_hd__buf_16$1_3 VGND VPWR sky130_fd_sc_hd__inv_2$2_0/A clk0b VGND VPWR
+ sky130_fd_sc_hd__buf_16$1
Xsky130_fd_sc_hd__clkbuf_4$1_3 VGND VPWR sky130_fd_sc_hd__clkbuf_4$1_3/X clk VGND
+ VPWR sky130_fd_sc_hd__clkbuf_4$1
Xsky130_fd_sc_hd__inv_1$2_11 VGND VPWR sky130_fd_sc_hd__inv_1$2_11/Y sky130_fd_sc_hd__inv_1$2_9/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__inv_1$2_12 VGND VPWR sky130_fd_sc_hd__inv_1$2_12/Y sky130_fd_sc_hd__inv_1$2_9/A
+ VGND VPWR sky130_fd_sc_hd__inv_1$2
Xsky130_fd_sc_hd__nand2_2$2_0 VGND VPWR sky130_fd_sc_hd__inv_1$2_0/A sky130_fd_sc_hd__nand2_2$2_0/A
+ sky130_fd_sc_hd__nand3_1$2_0/Y VGND VPWR sky130_fd_sc_hd__nand2_2$2
Xsky130_fd_sc_hd__nand2_2$2_1 VGND VPWR sky130_fd_sc_hd__inv_2$2_0/A sky130_fd_sc_hd__inv_1$2_7/A
+ sky130_fd_sc_hd__inv_1$2_9/A VGND VPWR sky130_fd_sc_hd__nand2_2$2
.ends

.subckt DCDC_CLKGATE$1 VNB VPB CLK GCLK GATE
X0 VPB a_n10903_655# a_n10954_427# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.0444e+12p pd=1.028e+07u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X1 a_n10779_472# a_n10903_655# a_n11165_605# VNB sky130_fd_pr__nfet_01v8 ad=2.3425e+11p pd=2.17e+06u as=2.384e+11p ps=2.18e+06u w=420000u l=150000u
X2 a_n11345_427# a_n11165_605# VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=0p ps=0u w=1e+06u l=150000u
X3 a_n10945_819# a_n11345_427# VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X4 a_n11019_453# a_n11345_427# VNB VNB sky130_fd_pr__nfet_01v8 ad=1.3425e+11p pd=1.49e+06u as=6.7175e+11p ps=6.86e+06u w=420000u l=150000u
X5 VNB a_n11513_605# GCLK VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X6 VNB a_n11165_605# a_n11345_427# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X7 a_n11513_605# CLK VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=4.064e+11p pd=2.55e+06u as=0p ps=0u w=640000u l=150000u
X8 a_n11387_453# CLK VNB VNB sky130_fd_pr__nfet_01v8 ad=8.82e+10p pd=1.26e+06u as=0p ps=0u w=420000u l=150000u
X9 a_n10903_655# CLK VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X10 VNB a_n10903_655# a_n10954_427# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X11 a_n10749_819# a_n10954_427# a_n11165_605# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.915e+11p pd=1.93e+06u as=1.974e+11p ps=1.78e+06u w=420000u l=150000u
X12 VPB a_n11345_427# a_n11513_605# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X13 a_n11165_605# a_n10903_655# a_n10945_819# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 a_n11513_605# a_n11345_427# a_n11387_453# VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X15 a_n11165_605# a_n10954_427# a_n11019_453# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=390000u l=150000u
X16 VNB GATE a_n10779_472# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 VPB a_n11513_605# GCLK VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X18 VPB GATE a_n10749_819# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X19 a_n10903_655# CLK VNB VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
.ends

.subckt DCDC_CAP_UNIT$1 m3_72_0# c1_100_100#
X0 c1_100_100# m3_72_0# sky130_fd_pr__cap_mim_m3_1 l=1.9e+07u w=7e+06u
.ends

.subckt DCAP_PMOS_98843368_X1_Y_1407ea6c$1 a_n206_897# w_n360_0#
X0 w_n360_0# a_n206_897# w_n360_0# w_n360_0# sky130_fd_pr__pfet_01v8 ad=2.625e+12p pd=1.09e+07u as=0p ps=0u w=2.1e+06u l=2.1e+06u
.ends

.subckt DP_NMOS_B_83449181_X1_Y_edeae765$1 a_372_897# a_200_252# a_230_483# a_405_483#
+ a_241_1232# a_147_483#
X0 a_147_483# a_372_897# a_405_483# a_241_1232# sky130_fd_pr__nfet_01v8 ad=4.452e+11p pd=4.42e+06u as=2.226e+11p ps=2.21e+06u w=840000u l=150000u
X1 a_230_483# a_200_252# a_147_483# a_241_1232# sky130_fd_pr__nfet_01v8 ad=2.226e+11p pd=2.21e+06u as=0p ps=0u w=840000u l=150000u
.ends

.subckt CCP_NMOS_B_82699349_X1__3a37f603$1 a_147_525# a_200_252# a_241_1232# a_230_525#
X0 a_147_525# a_230_525# a_200_252# a_241_1232# sky130_fd_pr__nfet_01v8 ad=2.226e+11p pd=2.74e+06u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# a_147_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.113e+11p pd=1.37e+06u as=0p ps=0u w=420000u l=150000u
.ends

.subckt DCDC_XSW_NMOS_0_1650326_24c8b01c$1 DP_NMOS_B_83449181_X1_Y_edeae765$1_0/a_230_483#
+ DCAP_PMOS_98843368_X1_Y_1407ea6c$1_0/w_n360_0# DP_NMOS_B_83449181_X1_Y_edeae765$1_0/a_405_483#
+ VSUBS DCAP_PMOS_98843368_X1_Y_1407ea6c$1_1/w_n360_0# m1_1376_224#
XDCAP_PMOS_98843368_X1_Y_1407ea6c$1_0 li_405_907# DCAP_PMOS_98843368_X1_Y_1407ea6c$1_0/w_n360_0#
+ DCAP_PMOS_98843368_X1_Y_1407ea6c$1
XDP_NMOS_B_83449181_X1_Y_edeae765$1_0 li_405_907# li_1437_823# DP_NMOS_B_83449181_X1_Y_edeae765$1_0/a_230_483#
+ DP_NMOS_B_83449181_X1_Y_edeae765$1_0/a_405_483# VSUBS m1_1376_224# DP_NMOS_B_83449181_X1_Y_edeae765$1
XDCAP_PMOS_98843368_X1_Y_1407ea6c$1_1 li_1437_823# DCAP_PMOS_98843368_X1_Y_1407ea6c$1_1/w_n360_0#
+ DCAP_PMOS_98843368_X1_Y_1407ea6c$1
XCCP_NMOS_B_82699349_X1__3a37f603$1_0 m1_1376_224# li_405_907# VSUBS li_1437_823#
+ CCP_NMOS_B_82699349_X1__3a37f603$1
.ends

.subckt DCAP_PMOS_98843368_X1_Y_f9c0cc87$1 a_n13_252# w_n118_0#
X0 w_n118_0# a_n13_252# w_n118_0# w_n118_0# sky130_fd_pr__pfet_01v8 ad=1.365e+12p pd=9.7e+06u as=0p ps=0u w=2.1e+06u l=2.1e+06u
.ends

.subckt DP_PMOS_B_25364157_X1_Y_12b887c0$1 a_230_441# a_405_441# a_372_897# a_200_252#
+ a_147_441# w_0_0#
X0 a_147_441# a_372_897# a_405_441# w_0_0# sky130_fd_pr__pfet_01v8 ad=6.678e+11p pd=6.1e+06u as=3.339e+11p ps=3.05e+06u w=1.26e+06u l=150000u
X1 a_230_441# a_200_252# a_147_441# w_0_0# sky130_fd_pr__pfet_01v8 ad=3.339e+11p pd=3.05e+06u as=0p ps=0u w=1.26e+06u l=150000u
.ends

.subckt CCP_PMOS_B_88242555_X1__44b71c81$1 a_147_525# a_200_252# w_0_0# a_230_525#
X0 a_147_525# a_230_525# a_200_252# w_0_0# sky130_fd_pr__pfet_01v8 ad=2.226e+11p pd=2.74e+06u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# a_147_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=1.113e+11p pd=1.37e+06u as=0p ps=0u w=420000u l=150000u
.ends

.subckt DCDC_XSW_PMOS_0_1650326_40a43b21$1 m1_1376_224# m1_1290_1316# DCAP_PMOS_98843368_X1_Y_f9c0cc87$1_0/w_n118_0#
+ DP_PMOS_B_25364157_X1_Y_12b887c0$1_0/a_230_441# DP_PMOS_B_25364157_X1_Y_12b887c0$1_0/a_405_441#
+ DCAP_PMOS_98843368_X1_Y_f9c0cc87$1_1/w_n118_0#
XDCAP_PMOS_98843368_X1_Y_f9c0cc87$1_0 li_405_907# DCAP_PMOS_98843368_X1_Y_f9c0cc87$1_0/w_n118_0#
+ DCAP_PMOS_98843368_X1_Y_f9c0cc87$1
XDCAP_PMOS_98843368_X1_Y_f9c0cc87$1_1 li_1437_823# DCAP_PMOS_98843368_X1_Y_f9c0cc87$1_1/w_n118_0#
+ DCAP_PMOS_98843368_X1_Y_f9c0cc87$1
XDP_PMOS_B_25364157_X1_Y_12b887c0$1_0 DP_PMOS_B_25364157_X1_Y_12b887c0$1_0/a_230_441#
+ DP_PMOS_B_25364157_X1_Y_12b887c0$1_0/a_405_441# li_405_907# li_1437_823# m1_1376_224#
+ m1_1290_1316# DP_PMOS_B_25364157_X1_Y_12b887c0$1
XCCP_PMOS_B_88242555_X1__44b71c81$1_0 m1_1376_224# li_405_907# m1_1290_1316# li_1437_823#
+ CCP_PMOS_B_88242555_X1__44b71c81$1
.ends

.subckt DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1 DCDC_XSW_NMOS_0_1650326_24c8b01c$1_0/DCAP_PMOS_98843368_X1_Y_1407ea6c$1_0/w_n360_0#
+ m1_1086_1316# m1_1258_1400# DCDC_XSW_NMOS_0_1650326_24c8b01c$1_0/DCAP_PMOS_98843368_X1_Y_1407ea6c$1_1/w_n360_0#
+ DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/DCAP_PMOS_98843368_X1_Y_f9c0cc87$1_0/w_n118_0#
+ DCDC_XSW_NMOS_0_1650326_24c8b01c$1_0/m1_1376_224# VSUBS DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/DCAP_PMOS_98843368_X1_Y_f9c0cc87$1_1/w_n118_0#
+ DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/m1_1376_224# DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/m1_1290_1316#
XDCDC_XSW_NMOS_0_1650326_24c8b01c$1_0 m1_1258_1400# DCDC_XSW_NMOS_0_1650326_24c8b01c$1_0/DCAP_PMOS_98843368_X1_Y_1407ea6c$1_0/w_n360_0#
+ m1_1086_1316# VSUBS DCDC_XSW_NMOS_0_1650326_24c8b01c$1_0/DCAP_PMOS_98843368_X1_Y_1407ea6c$1_1/w_n360_0#
+ DCDC_XSW_NMOS_0_1650326_24c8b01c$1_0/m1_1376_224# DCDC_XSW_NMOS_0_1650326_24c8b01c$1
XDCDC_XSW_PMOS_0_1650326_40a43b21$1_0 DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/m1_1376_224#
+ DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/m1_1290_1316# DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/DCAP_PMOS_98843368_X1_Y_f9c0cc87$1_0/w_n118_0#
+ m1_1258_1400# m1_1086_1316# DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/DCAP_PMOS_98843368_X1_Y_f9c0cc87$1_1/w_n118_0#
+ DCDC_XSW_PMOS_0_1650326_40a43b21$1
.ends

.subckt DCDC_CONV2TO1_0_1650326046$1 DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/DCDC_XSW_NMOS_0_1650326_24c8b01c$1_0/m1_1376_224#
+ DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/m1_1086_1316# m1_3150_1652# DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/m1_1258_1400#
+ m1_1172_2072# m1_140_1652# DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/m1_1086_1316# m1_3236_3332#
+ m1_54_3332# DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/m1_1258_1400# DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/m1_1376_224#
+ li_1695_151# VSUBS
XDCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0 m1_54_3332# DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/m1_1086_1316#
+ DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/m1_1258_1400# m1_3236_3332# m1_140_1652# DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/DCDC_XSW_NMOS_0_1650326_24c8b01c$1_0/m1_1376_224#
+ VSUBS m1_3150_1652# m1_1172_2072# li_1695_151# DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1
XDCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1 m1_54_3332# DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/m1_1086_1316#
+ DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/m1_1258_1400# m1_3236_3332# m1_140_1652# m1_1172_2072#
+ VSUBS m1_3150_1652# DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/m1_1376_224#
+ li_1695_151# DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1
.ends

.subckt CONV21_0$1 DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/m1_1086_1316#
+ DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/m1_1258_1400#
+ DCDC_CONV2TO1_0_1650326046$1_0/m1_3150_1652# DCDC_CONV2TO1_0_1650326046$1_0/m1_140_1652#
+ DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/m1_1086_1316#
+ DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/m1_1258_1400#
+ DCDC_CONV2TO1_0_1650326046$1_0/m1_3236_3332# DCDC_CONV2TO1_0_1650326046$1_0/m1_54_3332#
+ DCDC_CONV2TO1_0_1650326046$1_0/li_1695_151# DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/DCDC_XSW_NMOS_0_1650326_24c8b01c$1_0/m1_1376_224#
+ VSUBS DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/m1_1376_224#
+ DCDC_CONV2TO1_0_1650326046$1_0/m1_1172_2072#
XDCDC_CONV2TO1_0_1650326046$1_0 DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/DCDC_XSW_NMOS_0_1650326_24c8b01c$1_0/m1_1376_224#
+ DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/m1_1086_1316#
+ DCDC_CONV2TO1_0_1650326046$1_0/m1_3150_1652# DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_0/m1_1258_1400#
+ DCDC_CONV2TO1_0_1650326046$1_0/m1_1172_2072# DCDC_CONV2TO1_0_1650326046$1_0/m1_140_1652#
+ DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/m1_1086_1316#
+ DCDC_CONV2TO1_0_1650326046$1_0/m1_3236_3332# DCDC_CONV2TO1_0_1650326046$1_0/m1_54_3332#
+ DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/m1_1258_1400#
+ DCDC_CONV2TO1_0_1650326046$1_0/DCDC_HUNIT_CONV2TO1_0_1_73a3675f$1_1/DCDC_XSW_PMOS_0_1650326_40a43b21$1_0/m1_1376_224#
+ DCDC_CONV2TO1_0_1650326046$1_0/li_1695_151# VSUBS DCDC_CONV2TO1_0_1650326046$1
.ends

.subckt DCDC_CONV2TO1$1 m1_2610_5936# m1_1082_1484# m1_1942_308# VSUBS m1_2438_2240#
+ m1_738_1568# m1_566_5264# m1_910_5180# m2_398_0# m1_0_1736# m1_2610_1400# m2_226_0#
+ m2_3494_0#
XCONV21_0$1_0 m1_910_5180# m1_566_5264# m1_0_1736# m2_398_0# m1_1082_1484# m1_738_1568#
+ m2_3494_0# m2_226_0# m1_1942_308# m1_2610_5936# VSUBS m1_2610_1400# m1_2438_2240#
+ CONV21_0$1
.ends

.subckt NMOS_4T_64195651_X1_Y1__33ea6cae$1 a_233_357# a_200_897# a_241_1232# a_316_357#
X0 a_316_357# a_200_897# a_233_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=5.565e+11p pd=4.73e+06u as=5.565e+11p ps=4.73e+06u w=2.1e+06u l=150000u
.ends

.subckt PMOS_4T_13050553_X2_Y1__9ce07c45$1 a_230_357# a_200_252# a_147_357# w_0_0#
X0 a_230_357# a_200_252# a_147_357# w_0_0# sky130_fd_pr__pfet_01v8 ad=1.113e+12p pd=9.46e+06u as=1.113e+12p ps=9.46e+06u w=2.1e+06u l=150000u
X1 a_147_357# a_200_252# a_230_357# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
.ends

.subckt SKY130_FD_SC_HD__INV_4__a334a03f$1 PMOS_4T_13050553_X2_Y1__9ce07c45$1_0/a_147_357#
+ PMOS_4T_13050553_X2_Y1__9ce07c45$1_0/w_0_0# m1_430_896# m1_430_56# NMOS_4T_64195651_X1_Y1__33ea6cae$1_0/a_316_357#
+ VSUBS
XNMOS_4T_64195651_X1_Y1__33ea6cae$1_0 m1_430_56# m1_430_896# VSUBS NMOS_4T_64195651_X1_Y1__33ea6cae$1_0/a_316_357#
+ NMOS_4T_64195651_X1_Y1__33ea6cae$1
XPMOS_4T_13050553_X2_Y1__9ce07c45$1_0 m1_430_56# m1_430_896# PMOS_4T_13050553_X2_Y1__9ce07c45$1_0/a_147_357#
+ PMOS_4T_13050553_X2_Y1__9ce07c45$1_0/w_0_0# PMOS_4T_13050553_X2_Y1__9ce07c45$1
.ends

.subckt NMOS_4T_23806256_X3_Y1__7b841cd5$1 a_233_357# a_200_897# a_241_1232# a_316_357#
X0 a_316_357# a_200_897# a_233_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.1445e+12p pd=9.49e+06u as=1.6695e+12p ps=1.419e+07u w=2.1e+06u l=150000u
X1 a_316_357# a_200_897# a_233_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
X2 a_233_357# a_200_897# a_316_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
.ends

.subckt DCDC_MUX_NMOS_0_1650762_762dd4dc$1 li_921_1243# NMOS_4T_23806256_X3_Y1__7b841cd5$1_0/a_200_897#
+ NMOS_4T_23806256_X3_Y1__7b841cd5$1_1/a_200_897# VSUBS li_749_1327#
XNMOS_4T_23806256_X3_Y1__7b841cd5$1_1 li_749_1327# NMOS_4T_23806256_X3_Y1__7b841cd5$1_1/a_200_897#
+ VSUBS li_921_1243# NMOS_4T_23806256_X3_Y1__7b841cd5$1
XNMOS_4T_23806256_X3_Y1__7b841cd5$1_0 li_921_1243# NMOS_4T_23806256_X3_Y1__7b841cd5$1_0/a_200_897#
+ VSUBS li_749_1327# NMOS_4T_23806256_X3_Y1__7b841cd5$1
.ends

.subckt PMOS_4T_84335382_X3_Y1__e3cfcdb4$1 a_233_357# a_200_897# w_0_0# a_316_357#
X0 a_316_357# a_200_897# a_233_357# w_0_0# sky130_fd_pr__pfet_01v8 ad=1.1445e+12p pd=9.49e+06u as=1.6695e+12p ps=1.419e+07u w=2.1e+06u l=150000u
X1 a_316_357# a_200_897# a_233_357# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
X2 a_233_357# a_200_897# a_316_357# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
.ends

.subckt DCDC_MUX_PMOS_0_1650762_3e78fab9$1 li_749_1327# PMOS_4T_84335382_X3_Y1__e3cfcdb4$1_0/a_200_897#
+ PMOS_4T_84335382_X3_Y1__e3cfcdb4$1_1/a_200_897# m1_602_140# li_921_1243#
XPMOS_4T_84335382_X3_Y1__e3cfcdb4$1_0 li_921_1243# PMOS_4T_84335382_X3_Y1__e3cfcdb4$1_0/a_200_897#
+ m1_602_140# li_749_1327# PMOS_4T_84335382_X3_Y1__e3cfcdb4$1
XPMOS_4T_84335382_X3_Y1__e3cfcdb4$1_1 li_749_1327# PMOS_4T_84335382_X3_Y1__e3cfcdb4$1_1/a_200_897#
+ m1_602_140# li_921_1243# PMOS_4T_84335382_X3_Y1__e3cfcdb4$1
.ends

.subckt NMOS_4T_23806256_X3_Y1__034001d7$1 a_233_357# a_200_897# a_241_1232# a_316_357#
X0 a_316_357# a_200_897# a_233_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.1445e+12p pd=9.49e+06u as=1.6695e+12p ps=1.419e+07u w=2.1e+06u l=150000u
X1 a_316_357# a_200_897# a_233_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
X2 a_233_357# a_200_897# a_316_357# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
.ends

.subckt PMOS_4T_84335382_X3_Y1__f7f60cb8$1 w_n6_0# a_233_357# a_200_897# a_316_357#
X0 a_316_357# a_200_897# a_233_357# w_n6_0# sky130_fd_pr__pfet_01v8 ad=1.1445e+12p pd=9.49e+06u as=1.6695e+12p ps=1.419e+07u w=2.1e+06u l=150000u
X1 a_316_357# a_200_897# a_233_357# w_n6_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
X2 a_233_357# a_200_897# a_316_357# w_n6_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.1e+06u l=150000u
.ends

.subckt TGATE_26054449_0_165076_0e455568$1 NMOS_4T_23806256_X3_Y1__034001d7$1_0/a_200_897#
+ PMOS_4T_84335382_X3_Y1__f7f60cb8$1_0/a_200_897# m1_140_1316# PMOS_4T_84335382_X3_Y1__f7f60cb8$1_0/w_n6_0#
+ m1_226_1400# VSUBS
XNMOS_4T_23806256_X3_Y1__034001d7$1_0 m1_226_1400# NMOS_4T_23806256_X3_Y1__034001d7$1_0/a_200_897#
+ VSUBS m1_140_1316# NMOS_4T_23806256_X3_Y1__034001d7$1
XPMOS_4T_84335382_X3_Y1__f7f60cb8$1_0 PMOS_4T_84335382_X3_Y1__f7f60cb8$1_0/w_n6_0#
+ m1_226_1400# PMOS_4T_84335382_X3_Y1__f7f60cb8$1_0/a_200_897# m1_140_1316# PMOS_4T_84335382_X3_Y1__f7f60cb8$1
.ends

.subckt DCDC_MUX_TGATE_0_165076_add9839a$1 TGATE_26054449_0_165076_0e455568$1_0/m1_226_1400#
+ TGATE_26054449_0_165076_0e455568$1_0/NMOS_4T_23806256_X3_Y1__034001d7$1_0/a_200_897#
+ TGATE_26054449_0_165076_0e455568$1_0/PMOS_4T_84335382_X3_Y1__f7f60cb8$1_0/a_200_897#
+ TGATE_26054449_0_165076_0e455568$1_0/m1_140_1316# TGATE_26054449_0_165076_0e455568$1_0/PMOS_4T_84335382_X3_Y1__f7f60cb8$1_0/w_n6_0#
+ VSUBS
XTGATE_26054449_0_165076_0e455568$1_0 TGATE_26054449_0_165076_0e455568$1_0/NMOS_4T_23806256_X3_Y1__034001d7$1_0/a_200_897#
+ TGATE_26054449_0_165076_0e455568$1_0/PMOS_4T_84335382_X3_Y1__f7f60cb8$1_0/a_200_897#
+ TGATE_26054449_0_165076_0e455568$1_0/m1_140_1316# TGATE_26054449_0_165076_0e455568$1_0/PMOS_4T_84335382_X3_Y1__f7f60cb8$1_0/w_n6_0#
+ TGATE_26054449_0_165076_0e455568$1_0/m1_226_1400# VSUBS TGATE_26054449_0_165076_0e455568$1
.ends

.subckt DCDC_MUX_0_1650762210$1 li_2555_3091# m1_828_140# m1_2806_560# m1_656_2996#
+ li_921_2839# m1_312_560# VSUBS
XSKY130_FD_SC_HD__INV_4__a334a03f$1_0 m1_828_140# m1_828_140# m1_312_560# li_491_1411#
+ VSUBS VSUBS SKY130_FD_SC_HD__INV_4__a334a03f$1
XSKY130_FD_SC_HD__INV_4__a334a03f$1_1 m1_828_140# m1_828_140# m1_2806_560# m1_2322_3920#
+ VSUBS VSUBS SKY130_FD_SC_HD__INV_4__a334a03f$1
XDCDC_MUX_NMOS_0_1650762_762dd4dc$1_0 li_921_2839# li_491_1411# li_491_1411# VSUBS
+ VSUBS DCDC_MUX_NMOS_0_1650762_762dd4dc$1
XDCDC_MUX_PMOS_0_1650762_3e78fab9$1_0 m1_828_140# m1_2322_3920# m1_2322_3920# m1_828_140#
+ li_2555_3091# DCDC_MUX_PMOS_0_1650762_3e78fab9$1
XDCDC_MUX_TGATE_0_165076_add9839a$1_0 li_921_2839# m1_312_560# li_491_1411# m1_656_2996#
+ m1_828_140# VSUBS DCDC_MUX_TGATE_0_165076_add9839a$1
XDCDC_MUX_TGATE_0_165076_add9839a$1_1 li_2555_3091# m1_2322_3920# m1_2806_560# m1_656_2996#
+ m1_828_140# VSUBS DCDC_MUX_TGATE_0_165076_add9839a$1
.ends

.subckt DCDC_MUX$1 m2_427_0# m1_336_3180# m1_2572_3264# m1_2658_240# m1_3002_660#
+ m2_2834_0# VSUBS
XDCDC_MUX_0_1650762210$1_0 m1_2572_3264# m1_2658_240# m1_3002_660# m2_2834_0# m1_336_3180#
+ m2_427_0# VSUBS DCDC_MUX_0_1650762210$1
.ends

.subckt six_stage_conv$1 clk0b clk1b clk1 clk0 SEL_L[0] SEL_H[0] SEL_L[1] SEL_H[1]
+ SEL_L[2] SEL_H[2] SEL_L[3] SEL_H[3] SEL_L[4] SEL_H[4] SEL_L[5] SEL_H[5] VPWR VOUT
+ VGND
XDCDC_CAP_UNIT$1_6720 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6731 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6775 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6753 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6764 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6742 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6797 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6786 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1060 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1082 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1093 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1071 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_9 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_521 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_510 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_532 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6027 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6005 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6016 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6049 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6038 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5304 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5315 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5337 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5326 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4614 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4603 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5348 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5359 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3902 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4647 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4636 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4625 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3913 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3946 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3935 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3924 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4669 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4658 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3979 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3957 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3968 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6572 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_307 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_318 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_329 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6550 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6583 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6561 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5871 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5860 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6594 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5882 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5893 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_830 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_841 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3209 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_852 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_863 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_874 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_885 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2508 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2519 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_896 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1818 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1807 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1829 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_340 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_351 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_362 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_384 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_395 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_373 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5112 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5134 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5123 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5101 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4400 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4411 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4422 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5167 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5156 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5145 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4433 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4455 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4444 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3710 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5189 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5178 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4466 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4477 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4488 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3721 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3743 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3754 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3732 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4499 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3787 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3765 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3776 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3798 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_36 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_25 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_104 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_14 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7081 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7092 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7070 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_58 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_47 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_69 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_115 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_137 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_126 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6380 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6391 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_148 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_159 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5690 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3006 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3017 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3039 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3028 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_660 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_693 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2305 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_682 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_671 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2338 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2327 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2316 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2349 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1626 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1615 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1604 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1648 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1659 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1637 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_181 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_170 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_192 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4230 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4274 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4263 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4241 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4252 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3551 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3540 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3562 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4296 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4285 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2850 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3595 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3573 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3584 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2883 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2861 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2872 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2894 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_490 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2102 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2113 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2146 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1401 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2135 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2124 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2157 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2168 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1412 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2179 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1423 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1445 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1434 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1478 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1467 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1456 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1489 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4082 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4060 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4071 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4093 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3370 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3392 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3381 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2691 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2680 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1990 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6902 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6913 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6924 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6946 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6935 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6957 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6968 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6979 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1253 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1242 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1220 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1231 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1275 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1286 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1264 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1297 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6209 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5508 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5519 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4829 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4818 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4807 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6721 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6732 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6710 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6765 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6754 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6743 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6776 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6787 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6798 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1061 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1050 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1094 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1072 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1083 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_500 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_511 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_533 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_522 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6006 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6017 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6039 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6028 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5305 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5316 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5338 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5327 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4604 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5349 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3903 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4637 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4626 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4648 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4615 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3936 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3925 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3914 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4659 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3958 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3947 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3969 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6540 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6573 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_308 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_319 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6562 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6551 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6584 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6595 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5850 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5872 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5861 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5894 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5883 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_820 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_842 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_831 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_864 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_853 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_875 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2509 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_897 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_886 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1819 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1808 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_330 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_341 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_352 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_363 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_385 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_396 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_374 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5113 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5102 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5124 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4412 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4401 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4423 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5157 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5146 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5135 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4434 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4456 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4445 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3700 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3711 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5168 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5179 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4467 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4489 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4478 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3722 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3744 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3733 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3788 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3766 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3777 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3755 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3799 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7060 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_26 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_15 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7082 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7093 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7071 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_59 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_37 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_48 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_127 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_116 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_105 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6381 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6370 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5680 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_149 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_138 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6392 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5691 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4990 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3007 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_650 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3018 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3029 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_683 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_661 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_672 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_694 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2306 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2328 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2317 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2339 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1627 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1605 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1616 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1649 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1638 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_171 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_160 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_182 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_193 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4231 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4220 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4253 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4264 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4242 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3552 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3541 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3530 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4275 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4297 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4286 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2840 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2851 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3585 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3596 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3574 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3563 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2862 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2873 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2884 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2895 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_491 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_480 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2103 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2147 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1402 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2136 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2125 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2114 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2158 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2169 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1413 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1424 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1435 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1446 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1468 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1457 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1479 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4072 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4050 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4061 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4094 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4083 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3360 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3371 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3382 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3393 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2670 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2692 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2681 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1991 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1980 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6914 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6903 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6947 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6936 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6925 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6958 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6969 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1210 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1243 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1221 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1232 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1276 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1287 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1254 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1265 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1298 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3190 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5509 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4819 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4808 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6722 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6711 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6700 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6766 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6755 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6744 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6733 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6777 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6788 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6799 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1040 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1051 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1095 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1062 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1073 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1084 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_501 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_512 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_523 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_534 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6007 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6018 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6029 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5306 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5339 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5328 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5317 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4605 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4616 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4638 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4627 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3904 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3926 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3937 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3915 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4649 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3959 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3948 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6530 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6552 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6574 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_309 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6541 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6563 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6596 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5851 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5862 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5840 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6585 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5884 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5895 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5873 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_821 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_832 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_810 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_843 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_865 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_854 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_876 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_887 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_898 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1809 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_320 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_331 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_342 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_353 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_386 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_397 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_375 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_364 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5114 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5103 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5125 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4413 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4402 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5136 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5147 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5158 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4435 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4446 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3701 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4424 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5169 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4468 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4457 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4479 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3712 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3723 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3734 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3745 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3778 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3767 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3756 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3789 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7050 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_27 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_16 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7083 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7094 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7072 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7061 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_49 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_38 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_128 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_117 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_106 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6360 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6371 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6382 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_139 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5670 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6393 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5692 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5681 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4991 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4980 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_640 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3019 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3008 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_651 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_662 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_684 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_673 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2307 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2329 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2318 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_695 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1617 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1606 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1628 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1639 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_172 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_161 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_150 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_183 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_194 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4221 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4210 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3520 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4265 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4254 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4243 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4232 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3553 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3542 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3531 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4276 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4287 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4298 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2830 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2841 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3586 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3564 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3575 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2874 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2863 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2885 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2852 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3597 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2896 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6190 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_492 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_481 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_470 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2104 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2137 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2126 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2115 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2159 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2148 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1414 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1403 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1425 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1436 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1447 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1469 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1458 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4073 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4040 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4051 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4062 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3350 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4095 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4084 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3361 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2660 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3372 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3394 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3383 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2671 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2682 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2693 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1970 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1981 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1992 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6915 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6904 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6948 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6937 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6926 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6959 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1200 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1244 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1222 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1233 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1211 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1277 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1255 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1266 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1288 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1299 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3191 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3180 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2490 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4809 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6701 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6712 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6723 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6756 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6745 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6734 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6789 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6778 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6767 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1041 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1052 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1030 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1063 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1074 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1085 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1096 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_502 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_524 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_535 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_513 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6008 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6019 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5307 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5329 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5318 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4639 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4628 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4617 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4606 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3905 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3927 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3916 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3949 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3938 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6531 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6520 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6564 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6553 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6542 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6597 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6575 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5852 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5863 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5830 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5841 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6586 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5896 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5885 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5874 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_811 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_800 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_833 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_822 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_866 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_855 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_844 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_888 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_877 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_899 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_310 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_321 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_332 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_343 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_354 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_387 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_365 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_376 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_398 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5115 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5104 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4403 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4414 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5126 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5137 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5148 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4436 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4447 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3702 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4425 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5159 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4469 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4458 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3713 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3724 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3735 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3779 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3768 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3746 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3757 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7051 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7040 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_17 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7084 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7073 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7062 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_39 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_107 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_118 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_28 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7095 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6361 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6350 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6372 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5660 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_129 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6383 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5671 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6394 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5693 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5682 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4970 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4992 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4981 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_630 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_641 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3009 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_652 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_663 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_674 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2308 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_696 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2319 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_685 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1618 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1607 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1629 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_162 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_140 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_151 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_184 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_173 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_195 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4222 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4211 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4200 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3510 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4244 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4255 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4233 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3543 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3532 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3521 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4266 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4277 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4288 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2820 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2831 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2842 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3554 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3587 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3565 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3576 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4299 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2875 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2864 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2853 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3598 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2897 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2886 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6180 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6191 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5490 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_482 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_471 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_460 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_493 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2127 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2138 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2105 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2116 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2149 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1426 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1415 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1404 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1437 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1459 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1448 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4030 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4041 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4052 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4063 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3340 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4096 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4085 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4074 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3362 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3351 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2650 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3373 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3395 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3384 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2661 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2672 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2683 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2694 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1971 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1960 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1982 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1993 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6905 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6938 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6916 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6927 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6949 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_290 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1201 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1234 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1223 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1212 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1256 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1245 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1278 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1267 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1289 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3170 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3181 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3192 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2491 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2480 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1790 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6713 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6702 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6757 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6746 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6735 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6724 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6779 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6768 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1042 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1020 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1031 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1075 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1064 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1053 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1086 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1097 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_503 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_514 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_536 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_525 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6009 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5319 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5308 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4629 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4618 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4607 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3928 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3906 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3917 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3939 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6521 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6510 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6554 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6543 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6532 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5820 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6565 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6598 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6576 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5853 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5842 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5831 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6587 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5886 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5875 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5864 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5897 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_812 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_823 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_801 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_834 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_856 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_845 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_878 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_889 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_867 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_311 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_300 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_322 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_344 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_333 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_388 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_366 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_355 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_377 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_399 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5116 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5105 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4404 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5127 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5149 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5138 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4437 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4415 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4426 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4459 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4448 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3714 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3703 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3725 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3736 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3758 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3769 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3747 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7030 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7041 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_18 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7085 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7074 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7063 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7052 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6340 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_119 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_108 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_29 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7096 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6373 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6362 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6351 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5650 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5661 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6384 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6395 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5683 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5694 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4960 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5672 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4993 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4971 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4982 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_631 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_620 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_675 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_664 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_653 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_642 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2309 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_697 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_686 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1608 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1619 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_141 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_130 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_152 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_185 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_163 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_174 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_196 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4212 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4201 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3511 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3500 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4256 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4234 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4245 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4223 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3544 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3522 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3533 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4267 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4278 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4289 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2832 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2810 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2821 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3555 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3566 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3577 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2865 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2843 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2854 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2876 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3588 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3599 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2898 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2887 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6181 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6170 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6192 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5480 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5491 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4790 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_450 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_483 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_472 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_461 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_494 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2128 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2106 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2117 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1405 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1416 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1427 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2139 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1449 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1438 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4020 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4042 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4031 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4053 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4064 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3330 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3341 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4097 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4086 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3352 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4075 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2640 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2651 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3374 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3363 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3385 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2662 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2684 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2673 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3396 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2695 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1950 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1972 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1961 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1983 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1994 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6906 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6939 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6928 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6917 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_291 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_280 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1224 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1235 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1213 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1202 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1246 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1257 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1268 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1279 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3160 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3193 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3171 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3182 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2492 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2481 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2470 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1791 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1780 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6703 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6714 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6747 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6725 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6736 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6769 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6758 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1010 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1043 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1032 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1021 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1065 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1076 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1054 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1098 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1087 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_504 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_526 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_515 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_537 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5309 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4608 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4619 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3918 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3907 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3929 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6511 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6500 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6522 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6555 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6544 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6533 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5810 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6577 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6588 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6566 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6599 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5854 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5843 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5821 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5832 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5887 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5865 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5876 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5898 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_813 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_802 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_824 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_835 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_857 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_846 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_879 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_868 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_301 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_323 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_334 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_312 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_345 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_356 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_367 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_378 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_389 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5106 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4405 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5117 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5128 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5139 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4438 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4416 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4427 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4449 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3704 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3715 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3726 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3737 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3759 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3748 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7031 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7020 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7042 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7075 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7064 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7053 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6330 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_109 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_19 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7097 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7086 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6341 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6363 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6352 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5651 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5662 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6374 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6396 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5640 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6385 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5695 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5684 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5673 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4950 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4983 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4972 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4961 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4994 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_610 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_621 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_632 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_643 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_665 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_654 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_687 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_698 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_676 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1609 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_120 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_142 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_131 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_153 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_186 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_164 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_175 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_197 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4213 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4202 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3501 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4235 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4246 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4224 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2800 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3534 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3523 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3512 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4257 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4268 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4279 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2822 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2833 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2811 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3545 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3567 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3578 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3556 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2866 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2844 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2855 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3589 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2899 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2888 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2877 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6171 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6182 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6160 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6193 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5470 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5492 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5481 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4791 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4780 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_440 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_473 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_462 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_451 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_495 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_484 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2129 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2107 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2118 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1417 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1406 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1428 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1439 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4010 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4021 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4043 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4032 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4054 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4098 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3342 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3331 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3320 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4087 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3353 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4076 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4065 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2641 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2630 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3375 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3364 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3386 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2663 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2652 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2674 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3397 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1940 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2696 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2685 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1951 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1962 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1973 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1995 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1984 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6907 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6929 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6918 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_270 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_292 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_281 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1225 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1214 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1203 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1247 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1269 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1258 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1236 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3150 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3161 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3194 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3172 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3183 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2493 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2482 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2460 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2471 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1770 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1781 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1792 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6704 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6748 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6737 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6726 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6715 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6759 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1000 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1011 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1033 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1022 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1044 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1066 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1077 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1055 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1088 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1099 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2290 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_505 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_527 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_516 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4609 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3908 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3919 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6512 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6501 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6556 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6545 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6534 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6523 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5800 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5811 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6567 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6578 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6589 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5844 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5833 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5822 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5877 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5855 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5866 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5888 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5899 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_814 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_803 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_825 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_836 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_847 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_858 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_869 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_302 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_324 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_313 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_335 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_346 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_368 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_357 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_379 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5107 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5129 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5118 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4406 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4417 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4428 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4439 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3705 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3716 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3727 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3749 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3738 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7032 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7021 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7010 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7076 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7065 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7054 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7043 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6320 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6331 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7098 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7087 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6364 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6342 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6353 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5652 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6397 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6375 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6386 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5630 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5641 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5696 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5663 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5685 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4951 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5674 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4940 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4984 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4962 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4973 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4995 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_611 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_622 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_600 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_633 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_644 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_655 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_666 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_699 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_688 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_677 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_110 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_143 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_121 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_132 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_187 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_165 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_176 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_154 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_198 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4203 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3502 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4225 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4236 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4247 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4214 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3535 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3513 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3524 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4269 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4258 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2823 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2801 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2812 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3546 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3568 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3557 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2867 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2834 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2845 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2856 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3579 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2889 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2878 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6172 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6161 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6150 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6194 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6183 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5460 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5471 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5482 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5493 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4770 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4792 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4781 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_430 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_441 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_463 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_474 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_452 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_496 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_485 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2108 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2119 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1407 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1418 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1429 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4000 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4011 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3310 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4022 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4033 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4055 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4044 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3321 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3343 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3332 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4088 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4066 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4077 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2631 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2642 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2620 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4099 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3354 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3365 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3376 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2653 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2664 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2675 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3387 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3398 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1930 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2697 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2686 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1963 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1952 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1941 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1985 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1974 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1996 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5290 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6908 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6919 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_260 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_271 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_282 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_293 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1226 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1204 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1215 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1248 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1259 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1237 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3151 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3140 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3162 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2450 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3195 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3173 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3184 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2483 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2461 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2472 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2494 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1782 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1771 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1760 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1793 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6705 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6738 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6727 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6716 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6749 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_90 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_1001 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1012 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1023 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1034 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1045 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1067 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1056 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1078 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1089 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2291 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2280 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1590 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_528 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_506 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_517 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_3909 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6513 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6502 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6535 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6524 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6546 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5801 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6557 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6568 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6579 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5834 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5845 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5823 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5812 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5878 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5856 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5867 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5889 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_815 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_804 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_826 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_837 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_848 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_859 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_325 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_336 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_303 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_314 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_347 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_358 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_369 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5108 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5119 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4407 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4418 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4429 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3717 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3706 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3728 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3739 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7000 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7033 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7022 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7011 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7066 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7055 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7044 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6310 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6321 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5620 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7099 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7077 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7088 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6332 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6343 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6354 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5653 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6398 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6365 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6387 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5631 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5642 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6376 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5686 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5664 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5675 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4930 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4941 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5697 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4985 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4963 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4974 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4952 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4996 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_623 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_601 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_612 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_634 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_645 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_656 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_667 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_689 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_678 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_100 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_111 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_133 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_122 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_144 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_166 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_177 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_155 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_188 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_199 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4204 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4215 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4226 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4237 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3503 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3514 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3525 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4259 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4248 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2813 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2824 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2802 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3547 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3536 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3558 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3569 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2835 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2846 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2857 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2868 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2879 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6173 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6151 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6140 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6162 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6195 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6184 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5450 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5461 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5483 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5494 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5472 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4760 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4793 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4782 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4771 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_431 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_420 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_464 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_442 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_453 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_497 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_486 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_475 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2109 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1408 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1419 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4012 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4001 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3300 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4023 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4034 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4045 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3344 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3333 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3322 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4089 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3311 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4078 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4056 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4067 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2610 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2632 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2621 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3355 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3366 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3377 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2665 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2643 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2654 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3388 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3399 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1920 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1931 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2687 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2698 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2676 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1964 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1953 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1942 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1986 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1975 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1997 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5291 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5280 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4590 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6909 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_250 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_261 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_272 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_283 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_294 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1205 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1216 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1249 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1227 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1238 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3130 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3152 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3141 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3163 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2440 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3185 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3174 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2484 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2451 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2462 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2473 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3196 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2495 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1772 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1761 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1750 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1783 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1794 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6706 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6739 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6728 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6717 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_80 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_91 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_1002 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1013 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1024 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1068 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1046 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1035 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1057 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1079 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2292 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2281 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2270 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1580 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1591 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_518 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_507 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_529 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6503 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6547 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6514 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6536 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6525 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5802 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6569 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6558 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5835 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5824 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5813 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5857 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5868 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5846 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5879 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_805 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_816 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_827 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_838 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_849 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_326 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_304 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_315 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_337 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_348 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_359 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5109 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4408 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4419 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3707 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3718 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3729 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7001 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7023 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7012 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7034 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7056 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7045 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6311 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6322 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6300 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7078 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7089 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7067 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6333 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6355 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5610 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6344 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5621 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6388 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6366 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5632 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5643 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6377 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5654 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5687 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4931 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5665 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6399 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5676 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4942 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4920 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5698 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4953 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4975 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4964 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4986 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4997 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_602 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_613 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_624 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_635 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_646 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_657 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_679 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_668 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_101 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_134 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_112 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_123 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_167 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_178 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_156 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_145 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_189 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4238 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4216 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4227 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4205 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3515 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3504 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3526 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4249 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2814 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2803 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3537 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3548 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3559 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2825 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2836 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2847 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2858 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2869 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6130 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6163 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6152 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6141 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6196 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6174 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5440 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6185 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5451 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5462 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5484 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4750 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5495 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5473 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4783 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4761 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4772 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4794 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_421 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_432 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_410 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_465 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_443 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_454 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_498 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_487 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_476 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1409 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4002 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4013 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3301 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4024 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4035 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4046 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3334 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3323 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3312 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4079 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4057 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4068 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2600 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2611 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2622 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2633 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3345 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3356 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3367 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2666 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2644 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2655 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1910 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3389 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3378 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1921 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2699 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2688 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2677 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1943 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1932 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1954 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1965 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1976 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1998 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1987 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5270 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5292 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5281 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4580 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4591 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3890 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_240 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_251 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_262 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_273 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_295 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_284 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1217 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1206 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1228 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1239 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3131 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3120 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3142 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3153 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3164 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2430 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2441 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3186 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3175 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2452 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2463 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2474 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3197 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2496 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2485 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1773 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1740 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1762 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1751 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1784 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1795 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6707 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6718 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6729 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_70 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_81 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_92 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_1025 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1014 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1003 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1047 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1058 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1036 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1069 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2260 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2282 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2271 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2293 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1570 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1581 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1592 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_519 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_508 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6504 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6537 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6515 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6526 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6548 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5836 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5825 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5803 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5814 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6559 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5847 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5858 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5869 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_806 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_817 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_839 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_828 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2090 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_316 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_327 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_305 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_349 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_338 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4409 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3708 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3719 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7002 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7024 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7013 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7035 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7057 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7046 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6312 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6301 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5600 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7079 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7068 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6334 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6323 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5611 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6345 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5622 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6356 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6389 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6378 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6367 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5644 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5633 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5655 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5677 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4921 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5666 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4910 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4932 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5688 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5699 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4965 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4976 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4954 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4943 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4998 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4987 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_614 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_603 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6890 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_625 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_636 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_647 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_658 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_669 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_102 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_135 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_113 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_124 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_168 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_146 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_157 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_179 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4217 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4228 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4206 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3505 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3516 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4239 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2815 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2804 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3549 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3538 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3527 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2826 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2837 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2848 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2859 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6120 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6153 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6142 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6164 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6131 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6175 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6186 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5430 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5441 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6197 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5452 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5485 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4751 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4740 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5474 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5463 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4773 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4784 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5496 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4762 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4795 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_400 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_422 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_411 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_455 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_444 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_433 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_499 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_488 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_477 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_466 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4003 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4025 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4014 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4036 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3335 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3302 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3313 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3324 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4047 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4069 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4058 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2601 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2623 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2612 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3346 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3357 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3368 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2634 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2656 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2645 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1900 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1911 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3379 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1922 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2667 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2678 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2689 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1944 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1933 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1955 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1966 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1977 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1988 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1999 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5260 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5293 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5282 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5271 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4570 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4581 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4592 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3880 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3891 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_230 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_263 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_274 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_252 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_241 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_296 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_285 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1207 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1229 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1218 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3110 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3132 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3143 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3121 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3154 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3165 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2431 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2420 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3176 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2453 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2442 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2464 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2475 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3187 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3198 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1730 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2497 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2486 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1763 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1741 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1752 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1796 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1785 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1774 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5090 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6708 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6719 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_60 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_71 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_82 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_93 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_1004 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1015 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1059 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1037 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1048 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1026 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2250 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2261 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2283 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2272 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2294 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1571 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1560 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1593 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1582 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_509 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6538 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6505 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6516 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6527 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6549 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5804 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5826 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5815 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_MUX$1_0 SEL_L[0] DCDC_MUX$1_0/m1_336_3180# DCDC_MUX$1_0/m1_2572_3264# VPWR SEL_H[0]
+ VGND VGND DCDC_MUX$1
XDCDC_CAP_UNIT$1_5837 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5848 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5859 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_829 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_807 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_818 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2080 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2091 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1390 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_317 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_306 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_328 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_339 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_3709 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7003 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7014 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7036 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7025 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7047 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6313 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6302 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7069 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7058 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6335 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5601 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6324 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6346 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5623 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6357 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6368 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5634 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5612 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6379 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4900 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5656 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5678 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5667 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5645 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4911 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4933 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4922 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5689 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4955 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4966 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4944 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4999 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4988 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4977 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_604 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6891 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6880 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_615 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_626 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_637 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_648 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_659 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_103 DCDC_MUX$1_0/m1_336_3180# DCDC_CONV2TO1$1_66/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_1/m2_2834_0# DCDC_CONV2TO1$1_66/m1_738_1568# DCDC_CAP_UNIT$1_7130/m3_72_0#
+ DCDC_CAP_UNIT$1_7131/m3_72_0# clk1b clk0b DCDC_MUX$1_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_114 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_125 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_169 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_147 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_158 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_136 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4218 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4207 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3506 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3517 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4229 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2805 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3539 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3528 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2816 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2827 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2849 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2838 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6121 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6110 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6154 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6143 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6132 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6187 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6165 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5431 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6176 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5442 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5420 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5453 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6198 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4741 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4730 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5475 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5464 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5486 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4774 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4752 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5497 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4763 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4785 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4796 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_401 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_423 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_412 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_434 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_456 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_445 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_467 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_489 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_478 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4004 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4015 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4026 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4037 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3303 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3314 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3325 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4048 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4059 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2602 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2613 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2624 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_990 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3347 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3336 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3358 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2657 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2635 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2646 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1912 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1901 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3369 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2668 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2679 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1934 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1945 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1923 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1956 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1967 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1978 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1989 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5261 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5250 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5283 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5272 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5294 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4571 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4593 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4560 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4582 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3881 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3870 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3892 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_231 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_220 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_264 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_253 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_242 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_275 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_286 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_297 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1208 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1219 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3100 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3133 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3122 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3111 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3144 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3166 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3155 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2410 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2421 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2432 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3177 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2443 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2454 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2465 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3188 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3199 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1720 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2498 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2487 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2476 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1742 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1731 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1764 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1753 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1797 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1786 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1775 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5091 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5080 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4390 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6709 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_50 DCDC_MUX$1_0/m1_336_3180# DCDC_CONV2TO1$1_66/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_1/m2_2834_0# DCDC_CONV2TO1$1_66/m1_738_1568# DCDC_CAP_UNIT$1_7130/m3_72_0#
+ DCDC_CAP_UNIT$1_7131/m3_72_0# clk1b clk0b DCDC_MUX$1_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_72 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_61 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_94 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_83 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_1005 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1016 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1038 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1049 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1027 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2240 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2262 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2251 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2273 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2295 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2284 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1550 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1572 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1561 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1594 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1583 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6528 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6517 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6506 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6539 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5827 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5816 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5805 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_MUX$1_1 SEL_L[1] DCDC_MUX$1_1/m1_336_3180# DCDC_MUX$1_1/m1_2572_3264# VPWR SEL_H[1]
+ DCDC_MUX$1_1/m2_2834_0# VGND DCDC_MUX$1
XDCDC_CAP_UNIT$1_5849 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5838 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_808 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_819 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2070 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2081 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2092 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1380 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1391 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_318 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_307 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_329 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_7004 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7015 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7037 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7026 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7048 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6303 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7059 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6336 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6325 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6314 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5602 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5624 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6358 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6347 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5635 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5613 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6369 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5657 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4901 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4923 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5646 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5668 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4912 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4967 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5679 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4956 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4945 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4934 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4989 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4978 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_605 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6870 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6892 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6881 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_627 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_616 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_638 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_649 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_115 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_104 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_126 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_148 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_159 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_137 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4219 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4208 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3507 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2806 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3518 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3529 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2817 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2828 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2839 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6100 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6111 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5410 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6122 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6144 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6155 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6133 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6188 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6177 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5432 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6166 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5421 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5443 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6199 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5454 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5465 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4742 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4720 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4731 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5476 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4775 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4753 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5498 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5487 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4764 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4786 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4797 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_402 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_413 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_446 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_424 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_435 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_479 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_468 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_457 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4005 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4016 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4027 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3304 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3326 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3315 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4049 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4038 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2614 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2603 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_991 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_980 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3348 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3337 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3359 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2636 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2625 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2647 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1902 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1913 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2658 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2669 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1946 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1924 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1935 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1957 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1968 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1979 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_490 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5251 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5240 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5262 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5295 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5284 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5273 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4550 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4561 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4583 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4572 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3871 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3860 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4594 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3882 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3893 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_221 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_210 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_254 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_265 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_243 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_232 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_276 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_287 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_298 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1209 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3101 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3123 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3134 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3112 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3167 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3145 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3156 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2422 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2411 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2400 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2433 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2444 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2455 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2466 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3189 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3178 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1710 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1721 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2499 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2488 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2477 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1743 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1732 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1754 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1787 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1776 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1765 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1798 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5092 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5081 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5070 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4380 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4391 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3690 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_40 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_51 DCDC_MUX$1_0/m1_336_3180# DCDC_CONV2TO1$1_66/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_1/m2_2834_0# DCDC_CONV2TO1$1_66/m1_738_1568# DCDC_CAP_UNIT$1_7130/m3_72_0#
+ DCDC_CAP_UNIT$1_7131/m3_72_0# clk1b clk0b DCDC_MUX$1_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_73 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_62 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_84 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_95 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_1006 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1039 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1017 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1028 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2241 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2230 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2263 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2252 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2274 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2296 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2285 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1551 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1540 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1562 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1573 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1595 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1584 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6529 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6518 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6507 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5817 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5806 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_MUX$1_2 SEL_L[2] DCDC_MUX$1_3/m1_336_3180# DCDC_MUX$1_3/m1_2572_3264# VPWR SEL_H[2]
+ DCDC_MUX$1_3/m2_2834_0# VGND DCDC_MUX$1
XDCDC_CAP_UNIT$1_5828 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5839 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_809 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2060 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2082 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2071 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1370 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2093 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1392 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1381 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_308 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_319 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_7005 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7038 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7027 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7016 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6304 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7049 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6326 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6315 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6337 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5625 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5603 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6348 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5614 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6359 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5658 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4913 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4924 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5647 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5669 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5636 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4902 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4957 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4946 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4935 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4979 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4968 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6882 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6871 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6893 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_617 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_628 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_606 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_639 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6860 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_116 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_105 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_149 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_138 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_127 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4209 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3508 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3519 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2818 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2807 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2829 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6112 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6101 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5400 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6145 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6123 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6134 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6178 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6167 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5433 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5422 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5444 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5411 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6156 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6189 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5455 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4721 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4732 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4710 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5477 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5466 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4754 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4743 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5499 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5488 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4765 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4787 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4798 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4776 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_403 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_414 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_425 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_436 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_447 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6690 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_469 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_458 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4017 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4006 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4028 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3316 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3305 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4039 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2615 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2604 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_970 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_981 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_992 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3338 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3327 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3349 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2648 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2637 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2626 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1903 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2659 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1914 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1936 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1925 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1947 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1958 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1969 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_480 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_491 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5252 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5230 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5241 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5263 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4540 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5274 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5285 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4562 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5296 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4573 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4551 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4584 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3872 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3850 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3861 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4595 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3883 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3894 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_200 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_222 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_211 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_255 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_244 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_233 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_277 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_266 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_288 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_299 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3102 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3124 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3113 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3146 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3135 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3168 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3157 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2412 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2423 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2401 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2434 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2456 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2445 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3179 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1711 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1700 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2489 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2467 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2478 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1722 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1744 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1733 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1755 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1788 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1777 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1766 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1799 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5060 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5093 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5082 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5071 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4381 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4370 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4392 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3680 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3691 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2990 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_30 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_41 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_63 DCDC_MUX$1_0/m1_336_3180# DCDC_CONV2TO1$1_66/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_1/m2_2834_0# DCDC_CONV2TO1$1_66/m1_738_1568# DCDC_CAP_UNIT$1_7130/m3_72_0#
+ DCDC_CAP_UNIT$1_7131/m3_72_0# clk1b clk0b DCDC_MUX$1_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_74 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_85 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_52 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_96 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_1007 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1029 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1018 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2220 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2231 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2264 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2253 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2242 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2286 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2297 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2275 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1541 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1530 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1552 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1563 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1596 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1585 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1574 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6519 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6508 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5818 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5807 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5829 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_MUX$1_3 SEL_L[2] DCDC_MUX$1_3/m1_336_3180# DCDC_MUX$1_3/m1_2572_3264# VPWR SEL_H[2]
+ DCDC_MUX$1_3/m2_2834_0# VGND DCDC_MUX$1
XDCDC_CAP_UNIT$1_2050 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2072 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2061 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1360 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1371 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2083 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2094 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1382 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1393 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_309 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_7006 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7028 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7017 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7039 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6316 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6327 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6305 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5604 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6338 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5626 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6349 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5615 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5659 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4914 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5648 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5637 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4903 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4958 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4947 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4936 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4925 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4969 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6850 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6883 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6872 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_607 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_629 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_618 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6861 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6894 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1190 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_117 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_106 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_139 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_128 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_3509 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2819 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2808 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6102 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5401 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6124 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6135 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6113 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6146 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5434 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5412 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6168 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6179 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5423 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6157 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5445 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5456 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4733 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4722 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4700 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4711 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5467 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5489 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4755 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4744 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5478 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4766 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4799 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4777 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4788 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_404 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6680 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_437 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_415 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_426 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6691 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_459 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_448 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5990 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4007 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4018 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_960 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3317 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3306 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4029 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2605 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_971 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_993 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_982 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3328 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3339 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2627 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2638 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2616 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1904 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2649 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1915 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1937 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1926 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1948 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1959 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_470 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_481 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_492 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5231 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5220 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5242 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5253 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4541 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5264 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4530 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5286 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5275 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4563 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5297 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4552 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4574 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3840 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3851 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3862 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4585 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4596 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3873 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3884 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3895 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_201 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_212 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_245 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_234 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_256 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_223 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_267 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_278 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_289 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3103 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3114 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3125 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3147 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_790 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3136 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3158 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2413 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2402 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3169 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2435 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2424 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2457 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2446 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1701 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1712 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2479 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2468 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1723 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1734 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1745 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1767 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1778 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1756 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1789 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5050 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5094 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5083 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5072 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5061 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4360 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4382 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4371 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4393 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3681 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3670 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3692 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2991 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2980 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_20 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_31 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_42 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_64 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_75 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_53 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_97 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_86 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_1008 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1019 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2210 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2221 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2265 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2254 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2243 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1520 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2232 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2298 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2287 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2276 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1542 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1531 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1553 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1564 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1597 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1586 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1575 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4190 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6509 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5808 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5819 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_MUX$1_4 SEL_L[3] DCDC_MUX$1_5/m1_336_3180# DCDC_MUX$1_5/m1_2572_3264# VPWR SEL_H[3]
+ DCDC_MUX$1_5/m2_2834_0# VGND DCDC_MUX$1
XDCDC_CAP_UNIT$1_2040 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2073 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2051 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2062 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1361 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1350 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2084 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2095 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1372 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1394 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1383 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7007 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7029 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7018 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6317 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6328 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6306 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5605 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6339 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5616 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5649 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4915 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5627 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5638 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4904 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4948 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4926 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4937 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4959 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6840 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6884 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6873 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6862 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_608 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_619 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6851 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6895 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1180 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1191 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_107 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_118 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_129 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_2809 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6103 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6136 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6114 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6125 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6169 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5435 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5402 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5413 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5424 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6158 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6147 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5446 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5457 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4701 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4723 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4712 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5468 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4756 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4745 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4734 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5479 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4767 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4778 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4789 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_405 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6670 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6681 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6692 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_427 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_438 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_416 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_449 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5980 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5991 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4008 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4019 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_950 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3307 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2606 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_972 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_961 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_994 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_983 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3329 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3318 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2628 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2639 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2617 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1905 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1916 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1927 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1949 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1938 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_460 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_471 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_493 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_482 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5232 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5221 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5210 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5243 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5265 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5254 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4531 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4520 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5276 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3830 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4542 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5298 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4564 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4575 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5287 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4553 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3863 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3841 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3852 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4586 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4597 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3885 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3874 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3896 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_202 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_213 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_246 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_224 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_235 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_279 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_268 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_257 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3104 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3115 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3137 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3148 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3126 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3159 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2414 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2403 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_780 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_791 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2436 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2425 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2447 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1702 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2458 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2469 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1724 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1713 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1735 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1746 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1779 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1768 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1757 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_290 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5051 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5040 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5062 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5084 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5073 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4361 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4350 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4372 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4383 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5095 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4394 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3671 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3660 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2970 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3682 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3693 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2992 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2981 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_21 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_32 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_10 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_65 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_76 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_54 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_43 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_87 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_98 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_1009 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2200 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2211 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2222 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2255 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2244 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1510 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2233 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2299 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2288 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2266 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2277 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1543 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1532 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1521 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1554 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1587 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1576 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1565 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1598 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4191 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4180 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3490 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5809 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_MUX$1_5 SEL_L[3] DCDC_MUX$1_5/m1_336_3180# DCDC_MUX$1_5/m1_2572_3264# VPWR SEL_H[3]
+ DCDC_MUX$1_5/m2_2834_0# VGND DCDC_MUX$1
XDCDC_CAP_UNIT$1_2030 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2063 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2052 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2041 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1362 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1340 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1351 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2074 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2096 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2085 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1373 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1384 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1395 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7019 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7008 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6318 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6307 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6329 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5606 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5617 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5628 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5639 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4905 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4916 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4927 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4949 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4938 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6830 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6841 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6874 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6863 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_609 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6852 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6885 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6896 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1170 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1181 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1192 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_108 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_119 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6104 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6126 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6137 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6115 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5403 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5414 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5425 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6159 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6148 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5436 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5447 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5458 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4702 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4713 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4724 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4757 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4746 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4735 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5469 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4768 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4779 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6660 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6671 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6682 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_406 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_417 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_428 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_439 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5981 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5970 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6693 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5992 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4009 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_940 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_951 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3308 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_962 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_973 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_984 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3319 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2607 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2629 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2618 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_995 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1906 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1928 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1917 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1939 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_461 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_472 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_450 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_494 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_483 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5200 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5233 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5211 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5222 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5255 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4532 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4521 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5244 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4510 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5277 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5266 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3820 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4543 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5288 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4565 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5299 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4554 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3853 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3842 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3831 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4587 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4598 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4576 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3864 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3875 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3886 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3897 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_203 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_225 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_236 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_214 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_247 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6490 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_269 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_258 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3105 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3116 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3138 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_792 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3127 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3149 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_770 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_781 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2404 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2426 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2415 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2437 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2448 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1703 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2459 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1714 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1736 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1725 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1769 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1747 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1758 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_280 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_291 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5030 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5041 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5063 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4340 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5085 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5052 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5074 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4362 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4351 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4373 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5096 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4395 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3672 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4384 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3650 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3661 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2960 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3683 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3694 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2993 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2982 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2971 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_22 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_11 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_33 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_55 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_66 DCDC_MUX$1_0/m1_336_3180# DCDC_CONV2TO1$1_66/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_1/m2_2834_0# DCDC_CONV2TO1$1_66/m1_738_1568# DCDC_CAP_UNIT$1_7130/m3_72_0#
+ DCDC_CAP_UNIT$1_7131/m3_72_0# clk1b clk0b DCDC_MUX$1_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_44 DCDC_MUX$1_0/m1_336_3180# DCDC_CONV2TO1$1_66/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_1/m2_2834_0# DCDC_CONV2TO1$1_66/m1_738_1568# DCDC_CAP_UNIT$1_7130/m3_72_0#
+ DCDC_CAP_UNIT$1_7131/m3_72_0# clk1b clk0b DCDC_MUX$1_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_77 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_88 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_99 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_2201 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2212 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2256 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2245 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2223 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1511 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1500 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2234 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2289 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2267 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2278 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1533 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1544 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1522 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1577 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1566 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1555 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1588 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1599 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4170 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4181 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3480 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4192 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3491 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2790 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_MUX$1_6 SEL_L[4] DCDC_MUX$1_7/m1_336_3180# DCDC_MUX$1_7/m1_2572_3264# VPWR SEL_H[4]
+ DCDC_MUX$1_7/m2_2834_0# VGND DCDC_MUX$1
XDCDC_CAP_UNIT$1_2031 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2020 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2064 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2042 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2053 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1330 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1341 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1352 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2075 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2086 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2097 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1374 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1363 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1396 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1385 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7009 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6319 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6308 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5607 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5618 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5629 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4906 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4928 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4939 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4917 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6831 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6820 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6875 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6864 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6853 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6842 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6886 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6897 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1160 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1171 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1193 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1182 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_109 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6105 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6127 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6116 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5415 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5426 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5404 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6149 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6138 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5437 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5448 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5459 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4714 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4703 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4747 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4736 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4725 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4758 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4769 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6650 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6661 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6672 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6683 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_407 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_418 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_429 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6694 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5971 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5960 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5982 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5993 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_941 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_930 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_952 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_974 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_963 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_985 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3309 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2608 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2619 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_996 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1907 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1918 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1929 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_440 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_462 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_451 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_473 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_484 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_495 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5234 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5223 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5212 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5201 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4522 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4511 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5245 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5256 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4500 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5267 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3810 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3821 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4533 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4544 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5278 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5289 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4555 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3854 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3843 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3832 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4588 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4577 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4566 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4599 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3865 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3876 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3887 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3898 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_204 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_237 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_226 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_215 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6480 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6491 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_248 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_259 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5790 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3106 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_760 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_793 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3139 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3128 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3117 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_771 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_782 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2405 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2438 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2427 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2416 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2449 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1704 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1737 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1726 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1715 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1759 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1748 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_281 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_270 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_292 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5020 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5031 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5042 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5064 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4330 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5053 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5075 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4363 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4352 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4374 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4341 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5086 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5097 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4396 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4385 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3651 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3662 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3640 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2961 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2950 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3673 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3695 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3684 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2994 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2983 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2972 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_23 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_12 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_67 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_56 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_34 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_45 DCDC_MUX$1_0/m1_336_3180# DCDC_CONV2TO1$1_66/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_1/m2_2834_0# DCDC_CONV2TO1$1_66/m1_738_1568# DCDC_CAP_UNIT$1_7130/m3_72_0#
+ DCDC_CAP_UNIT$1_7131/m3_72_0# clk1b clk0b DCDC_MUX$1_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_89 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_78 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_590 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2202 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2213 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2246 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2224 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1501 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2235 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2257 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2279 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2268 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1512 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1545 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1534 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1523 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1578 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1567 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1556 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1589 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4160 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4171 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4182 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3470 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4193 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3481 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3492 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2780 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2791 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_MUX$1_7 SEL_L[4] DCDC_MUX$1_7/m1_336_3180# DCDC_MUX$1_7/m1_2572_3264# VPWR SEL_H[4]
+ DCDC_MUX$1_7/m2_2834_0# VGND DCDC_MUX$1
XDCDC_CAP_UNIT$1_2021 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2010 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1320 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2032 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2043 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2054 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1331 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1353 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1342 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2065 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2076 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2098 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2087 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1364 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1375 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1386 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1397 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6309 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5608 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5619 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4929 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4918 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4907 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6810 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6821 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6832 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6854 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6843 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6865 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6887 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6876 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6898 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1161 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1150 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1183 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1172 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1194 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6106 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6117 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6128 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5416 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5405 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6139 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5438 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5427 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5449 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4704 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4748 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4737 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4726 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4715 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4759 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6640 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6662 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6651 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6673 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_408 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_419 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6695 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5972 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5961 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5950 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6684 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5994 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5983 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_942 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_931 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_920 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_953 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_975 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_964 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2609 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_986 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_997 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1908 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1919 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_430 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_441 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_463 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_452 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_485 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_474 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_496 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5224 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5213 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5202 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5246 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5235 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4523 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4512 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5257 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4501 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5268 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3811 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3800 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4545 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4534 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5279 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4556 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3844 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3833 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3822 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4567 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4578 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4589 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3855 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3866 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3888 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3877 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3899 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_238 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_205 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_216 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_227 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6470 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6481 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6492 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_249 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5780 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5791 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3107 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_750 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3129 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3118 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_761 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_772 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_783 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_794 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2417 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2439 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2428 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2406 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1705 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1727 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1716 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1738 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1749 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_271 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_260 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_293 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_282 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5021 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5010 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5032 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5065 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4331 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4320 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5054 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5043 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5076 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4364 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4353 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4342 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5087 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5098 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4397 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4375 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4386 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3663 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3652 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3630 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3641 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2940 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2951 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3696 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3674 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3685 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2962 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2973 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2984 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2995 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_24 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_13 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_57 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_46 DCDC_MUX$1_0/m1_336_3180# DCDC_CONV2TO1$1_66/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_1/m2_2834_0# DCDC_CONV2TO1$1_66/m1_738_1568# DCDC_CAP_UNIT$1_7130/m3_72_0#
+ DCDC_CAP_UNIT$1_7131/m3_72_0# clk1b clk0b DCDC_MUX$1_0/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_35 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_79 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_68 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_580 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_591 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2203 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2214 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2247 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2225 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2236 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1502 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2258 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2269 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1524 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1513 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1535 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1546 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1557 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1568 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1579 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4150 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4161 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4172 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3460 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3471 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4194 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4183 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3493 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3482 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2781 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2770 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2792 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_MUX$1_8 SEL_L[5] DCDC_MUX$1_9/m1_336_3180# DCDC_MUX$1_9/m1_2572_3264# VPWR SEL_H[5]
+ DCDC_MUX$1_9/m2_2834_0# VGND DCDC_MUX$1
XDCDC_CAP_UNIT$1_2022 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2000 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2011 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1310 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2033 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2055 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2044 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1332 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1321 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1343 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2066 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2077 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2088 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1365 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1354 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1376 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1387 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2099 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1398 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3290 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5609 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4919 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4908 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6811 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6800 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6822 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6866 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6855 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6833 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6844 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6888 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6877 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6899 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1151 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1162 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1140 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1184 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1173 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1195 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6107 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6118 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5406 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5417 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6129 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5439 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5428 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4705 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4738 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4727 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4716 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4749 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6641 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6630 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6652 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6663 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6674 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_409 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6696 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6685 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5940 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5951 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5962 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5995 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5984 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5973 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_910 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_932 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_921 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_943 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_965 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_954 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_976 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_987 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_998 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1909 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_420 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_442 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_431 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_453 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_464 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_475 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_486 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_497 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5214 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5225 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5203 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5247 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4502 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5258 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5236 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4513 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3812 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3801 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4535 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4524 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5269 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4546 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3845 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3823 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3834 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4568 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4579 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4557 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3867 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3856 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3878 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3889 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_228 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_217 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_206 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6471 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6460 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6482 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_239 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5770 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5781 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6493 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5792 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_751 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_740 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3108 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3119 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_762 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_784 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_773 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_795 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2429 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2418 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2407 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1706 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1728 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1717 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1739 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_261 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_272 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_250 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_283 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_294 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5000 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5022 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5011 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5033 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5066 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4310 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4321 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5055 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5044 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4365 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4354 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4343 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4332 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3620 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5099 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5088 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5077 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4398 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4376 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3653 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4387 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3631 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3642 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2930 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2941 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2952 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3664 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3686 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3675 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2963 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2974 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2985 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3697 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2996 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_14 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_25 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_36 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_47 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_58 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_69 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6290 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2204 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_592 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_581 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_570 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2215 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2237 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2226 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2259 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2248 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1525 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1514 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1503 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1536 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1547 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1569 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1558 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4140 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4151 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4173 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4162 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3461 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3450 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4184 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4195 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2760 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3472 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3494 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3483 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2782 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2771 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2793 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_MUX$1_9 SEL_L[5] DCDC_MUX$1_9/m1_336_3180# DCDC_MUX$1_9/m1_2572_3264# VPWR SEL_H[5]
+ DCDC_MUX$1_9/m2_2834_0# VGND DCDC_MUX$1
XDCDC_CAP_UNIT$1_2012 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2001 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1300 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1311 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2045 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2034 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2023 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1322 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1333 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1344 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2067 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2056 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2078 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2089 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1366 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1355 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1377 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1399 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1388 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3280 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3291 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2590 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4909 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6812 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6801 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6823 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6856 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6834 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6845 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6889 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6878 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6867 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1141 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1152 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1130 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1174 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1163 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1185 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1196 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6108 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6119 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5407 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5429 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5418 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4739 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4728 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4706 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4717 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6631 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6620 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6653 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6642 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6664 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5930 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6675 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6697 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6686 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5941 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5952 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5963 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5996 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5985 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5974 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_900 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_933 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_911 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_922 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_944 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_955 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_966 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_977 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_988 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_999 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_421 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_410 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_432 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_443 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_454 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_465 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_476 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_487 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_498 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5215 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5204 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5248 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5226 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4503 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5259 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5237 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4514 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3802 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4536 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4525 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4547 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3835 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3813 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3824 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4558 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4569 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3868 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3857 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3879 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3846 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_229 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_218 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_207 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6461 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6450 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6483 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6472 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5760 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5771 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6494 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5782 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5793 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_741 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_730 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3109 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_763 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_752 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_774 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_785 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2408 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2419 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_796 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1707 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1718 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1729 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_262 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_240 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_251 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_273 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_295 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_284 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5001 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5012 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5023 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5067 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4300 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4322 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4311 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5045 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5056 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5034 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4355 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4344 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4333 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3610 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5089 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5078 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4377 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4366 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3654 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3632 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3643 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3621 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4388 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4399 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2920 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2931 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2942 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3687 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3665 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3676 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2964 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2975 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2953 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3698 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2997 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2986 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_15 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_26 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_48 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_37 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_59 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6280 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6291 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5590 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_582 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_593 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_571 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_560 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2216 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2205 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2238 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2227 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2249 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1515 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1526 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1504 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1548 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1537 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1559 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4130 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4152 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4141 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4163 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3462 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3451 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3440 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4185 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4174 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4196 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2750 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3473 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3495 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3484 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2783 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2761 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2772 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2794 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_390 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2013 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2002 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1301 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2046 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2024 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2035 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1312 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1323 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1334 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2079 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2057 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2068 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1367 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1356 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1345 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1378 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1389 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3270 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3292 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3281 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2580 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2591 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1890 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6813 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6802 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6857 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6835 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6846 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6824 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6879 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6868 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1153 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1120 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1142 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1131 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1164 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1175 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1186 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1197 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6109 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5408 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5419 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4707 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4718 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4729 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6621 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6632 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6610 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6654 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6643 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6665 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5920 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6698 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6676 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6687 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5942 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5953 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5931 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5986 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5997 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5975 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5964 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_912 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_901 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_923 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_956 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_967 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_934 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_945 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_978 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_989 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_400 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_411 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_422 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_433 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_444 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_455 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_466 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_477 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_488 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_499 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5216 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5205 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5238 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5227 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4504 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5249 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3803 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4515 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4526 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4537 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3836 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3825 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3814 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4548 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4559 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3869 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3858 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3847 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7130 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6440 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_208 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_219 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6462 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6451 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6473 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5750 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5761 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5772 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6495 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6484 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5783 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5794 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_731 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_720 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_742 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_753 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_764 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_775 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_786 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2409 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_797 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1708 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1719 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_263 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_230 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_252 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_241 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_296 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_274 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_285 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5002 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5013 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5024 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4312 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4301 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5046 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5057 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5035 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4356 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4345 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3600 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4334 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4323 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3611 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5079 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5068 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4367 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4378 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3622 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3633 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4389 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3644 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2921 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2932 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2910 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2943 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3677 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3666 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3655 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2965 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2976 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2954 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3688 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3699 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2998 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2987 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_27 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_16 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_38 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_49 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6281 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6270 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5580 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6292 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5591 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4890 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_550 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_583 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_561 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_572 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_594 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2217 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2206 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2228 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2239 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1505 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1527 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1516 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1549 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1538 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4131 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4120 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4153 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4142 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4164 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3452 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3441 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3430 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4175 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4197 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4186 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2740 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2751 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3463 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3474 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3496 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3485 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2784 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2762 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2773 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2795 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_380 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_391 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2003 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1302 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2025 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2036 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2014 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1335 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1324 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1313 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2058 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2069 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2047 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1368 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1357 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1346 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1379 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3271 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3260 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3293 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3282 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2570 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2592 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2581 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1880 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1891 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6814 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6803 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6847 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6825 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6836 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6869 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6858 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1110 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1121 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1143 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1132 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1154 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1176 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1165 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1198 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1187 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3090 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5409 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4708 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4719 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6611 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6622 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6600 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6655 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6644 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6633 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5910 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5921 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6666 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6699 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6677 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5954 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5932 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5943 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6688 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5987 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5965 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5976 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5998 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_902 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_913 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_924 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_946 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_935 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_957 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_968 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_979 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_412 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_401 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_445 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_434 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_423 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_456 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_467 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_478 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_489 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5206 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5239 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5228 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5217 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4505 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4516 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4527 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4538 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3815 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3826 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3804 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4549 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3859 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3848 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3837 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7131 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7120 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6430 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_209 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6441 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6463 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6452 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6474 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5762 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5751 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5740 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6496 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6485 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5773 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5784 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5795 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_721 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_732 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_710 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_754 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_765 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_743 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_787 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_776 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_798 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1709 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_220 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_242 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_231 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_253 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_264 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_275 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_286 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_297 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5003 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5014 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4302 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4313 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5047 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5058 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5036 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5025 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4346 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3601 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4324 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4335 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5069 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2900 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4357 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4379 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4368 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3623 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3634 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3645 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3612 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2922 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2933 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2911 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3667 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3678 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3656 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2966 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2944 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2955 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3689 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2988 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2999 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2977 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_17 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_28 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_39 DCDC_MUX$1_3/m1_336_3180# DCDC_CONV2TO1$1_88/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_5/m2_2834_0# DCDC_CONV2TO1$1_88/m1_738_1568# DCDC_CAP_UNIT$1_7121/m3_72_0#
+ DCDC_CAP_UNIT$1_7125/m3_72_0# clk1b clk0b DCDC_MUX$1_3/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6282 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6260 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6271 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5570 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6293 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5592 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5581 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4880 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4891 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_540 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_584 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_573 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_562 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_551 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_595 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2218 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2207 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2229 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1506 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1517 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1539 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1528 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4121 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4110 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3420 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4154 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4132 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4143 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3442 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3431 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3453 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4165 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4176 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4198 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4187 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2741 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2730 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3464 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3475 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3486 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2752 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2785 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2763 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2774 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3497 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2796 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6090 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_381 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_392 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_370 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2004 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2037 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2026 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2015 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1314 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1303 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1325 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2059 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2048 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1369 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1358 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1336 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1347 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3250 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3261 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3294 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3272 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3283 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2571 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2560 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2593 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2582 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1881 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1870 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1892 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6804 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6815 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6848 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6826 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6837 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6859 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1100 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1111 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1122 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1144 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1133 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1155 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1177 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1166 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1199 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1188 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3080 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3091 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2390 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4709 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6612 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6623 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6601 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6656 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6634 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6645 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5900 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5911 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6667 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6678 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5933 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5922 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5944 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6689 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5955 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5966 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5977 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5988 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5999 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_903 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_914 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_936 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_947 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_925 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_958 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_969 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_402 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_435 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_424 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_413 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_457 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_446 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_468 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_479 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5207 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5229 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5218 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4517 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4528 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4506 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3816 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3827 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3805 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4539 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3838 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3849 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7121 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7110 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6431 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6420 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6453 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6464 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6442 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5763 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5752 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5741 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5730 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6497 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6475 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6486 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5774 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5785 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5796 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_733 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_722 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_711 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_700 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_755 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_766 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_744 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_788 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_799 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_777 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_210 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_221 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_243 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_232 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_254 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_265 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_276 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_287 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_298 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5004 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5015 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5026 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4303 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5048 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5037 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4347 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3602 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4336 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4314 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4325 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5059 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4358 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4369 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3624 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3635 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3613 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2934 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2912 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2923 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2901 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3668 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3657 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3646 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2967 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2956 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2945 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3679 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2989 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2978 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_18 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_29 DCDC_MUX$1_1/m1_336_3180# DCDC_CONV2TO1$1_84/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_3/m2_2834_0# DCDC_CONV2TO1$1_84/m1_738_1568# DCDC_CAP_UNIT$1_7127/m3_72_0#
+ DCDC_CAP_UNIT$1_7129/m3_72_0# clk1b clk0b DCDC_MUX$1_1/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6250 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6272 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6261 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5560 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5571 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6294 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6283 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5593 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5582 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4870 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4892 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4881 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_541 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_530 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_574 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_552 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_563 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_596 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_585 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2208 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2219 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1518 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1507 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1529 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4100 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4122 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4111 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3410 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4144 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4133 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4155 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3443 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3432 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3421 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4166 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4177 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4188 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2742 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2720 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2731 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3454 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3465 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3476 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3487 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4199 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2764 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2753 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2775 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3498 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2797 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2786 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6091 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6080 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5390 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_371 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_382 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_360 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_393 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2016 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2027 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2005 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1326 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1315 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1304 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2038 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2049 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1359 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1337 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1348 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3251 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3262 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3240 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3273 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3284 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2550 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3295 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2583 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2561 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2572 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2594 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1860 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1871 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1882 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1893 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6805 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6816 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6827 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6838 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6849 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_190 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1101 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1123 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1112 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1134 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1156 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1145 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1167 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1178 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1189 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3070 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3092 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3081 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2391 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2380 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1690 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6613 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6602 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6635 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6646 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6624 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5901 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5912 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6657 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6668 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6679 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5934 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5945 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5923 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5967 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5978 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5956 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5989 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_915 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_904 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_937 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_948 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_926 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_959 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_403 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_436 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_425 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_414 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_458 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_447 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_469 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5219 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5208 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4518 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4529 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4507 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3806 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3817 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3839 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3828 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7100 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7122 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7111 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6421 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6410 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5720 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6454 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6432 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6465 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6443 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5753 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5731 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5742 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6487 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6476 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6498 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5775 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5764 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5786 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5797 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_712 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_723 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_701 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_734 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_756 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_745 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_767 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_778 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_789 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_211 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_200 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_244 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_222 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_233 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_255 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_277 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_266 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_299 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_288 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5005 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5027 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5016 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4304 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5049 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5038 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4337 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4326 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4315 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4359 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4348 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3603 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3614 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3625 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3636 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2913 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2924 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2902 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3669 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3658 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3647 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2935 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2957 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2946 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2968 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2979 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_19 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6240 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6251 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6262 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6273 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5561 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5550 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6284 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6295 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4860 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5572 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5594 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5583 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4871 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4893 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4882 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_520 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_531 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_575 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_553 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_564 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_542 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_586 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_597 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2209 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1508 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1519 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4101 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4112 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3411 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3400 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4134 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4145 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4123 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3444 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3433 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3422 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4156 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4167 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4189 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4178 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2732 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2710 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2721 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3466 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3477 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3455 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2743 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2765 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2776 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2754 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3488 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3499 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2787 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2798 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6081 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6070 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6092 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5391 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5380 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4690 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_372 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_383 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_361 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_350 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_394 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2028 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2006 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2017 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1305 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1316 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2039 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1327 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1338 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1349 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3230 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3241 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3252 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3274 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3263 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3285 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2540 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2584 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2551 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2562 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2573 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3296 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2595 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1872 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1861 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1850 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1894 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1883 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6806 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6817 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6828 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6839 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_90 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_180 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_191 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1102 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1124 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1135 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1113 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1146 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1157 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1168 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1179 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3060 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3093 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3082 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3071 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2370 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2392 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2381 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1680 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1691 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_0 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6614 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6603 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6636 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6647 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6625 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5902 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6658 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6669 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5913 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5924 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5935 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5968 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5979 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5957 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5946 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_905 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_927 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_949 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_938 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_916 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_426 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_404 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_415 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_437 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_459 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_448 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5209 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4519 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4508 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3807 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3818 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3829 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7123 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7112 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7101 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6422 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6411 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6400 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5710 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6455 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6444 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6433 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5721 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6466 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5754 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5732 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5743 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6488 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6477 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5776 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5765 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5787 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6499 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5798 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_713 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_724 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_702 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_746 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_757 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_735 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_779 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_768 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_201 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_245 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_234 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_212 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_223 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_256 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_278 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_267 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_289 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5006 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5028 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5017 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5039 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4338 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4327 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4305 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4316 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4349 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3604 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3615 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3626 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2903 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2914 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2925 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3659 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3648 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3637 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2958 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2936 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2947 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2969 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6230 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6252 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6241 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6263 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5562 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5540 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5551 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6274 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6285 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6296 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4850 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5573 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5595 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5584 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4861 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4872 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4883 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4894 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_521 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_532 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_510 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_565 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_554 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_543 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_587 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_576 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_598 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1509 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4102 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4113 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3401 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4135 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4146 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4124 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3434 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3423 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3412 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4157 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4179 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4168 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2733 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2700 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2711 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2722 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3445 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3467 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3456 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3478 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2744 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2766 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2755 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3489 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2788 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2777 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2799 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6071 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6082 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6060 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6093 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5370 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5392 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5381 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4680 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4691 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3990 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_340 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_373 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_362 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_351 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_384 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_395 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2018 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2007 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1317 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1306 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2029 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1328 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1339 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3242 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3231 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3253 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3220 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2530 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3275 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3264 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3286 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2541 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2563 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2574 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2552 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3297 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2596 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2585 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1840 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1873 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1851 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1862 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1884 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1895 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6807 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6818 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6829 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_80 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_181 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_91 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_170 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_192 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1103 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1125 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1114 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1147 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1158 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1136 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1169 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3050 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3061 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3083 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3072 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3094 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2360 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2371 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2382 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2393 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1670 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1681 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1692 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_1 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6604 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6626 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6637 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6615 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5903 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6659 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6648 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5936 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5914 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5925 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5969 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5947 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5958 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_906 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_917 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_928 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_939 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2190 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_427 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_405 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_416 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_438 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_449 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4509 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3808 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3819 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7124 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7113 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7102 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6412 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6401 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5711 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5700 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6423 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6456 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6445 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6434 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5722 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6467 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5733 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5744 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6489 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6478 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5755 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5766 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5777 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5788 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5799 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_714 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_703 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_747 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_725 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_736 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6990 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_758 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_769 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_202 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_235 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_213 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_224 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_246 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_268 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_257 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_279 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5007 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5029 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5018 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4328 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4317 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4306 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3605 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4339 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3616 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3627 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2915 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2904 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3638 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3649 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2937 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2926 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2948 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2959 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6220 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6231 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6253 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6242 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6264 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5530 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5541 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5552 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6275 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6286 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6297 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4840 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5563 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4851 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5574 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5596 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5585 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4862 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4873 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4884 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4895 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_500 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_522 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_511 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_533 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_544 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_555 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_566 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_577 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_599 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_588 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4103 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3402 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4136 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4125 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4114 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3435 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3424 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3413 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4147 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4158 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4169 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2701 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2723 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2712 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3457 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3446 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3468 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2745 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2767 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2756 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2734 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3479 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2789 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2778 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6072 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6050 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6061 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6083 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6094 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5360 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5393 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5382 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5371 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4670 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4692 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4681 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3980 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3991 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_330 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_374 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_363 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_341 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_352 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_396 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_385 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2019 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2008 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1307 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1318 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1329 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3210 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3243 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3232 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3221 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3254 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2531 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2520 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3276 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3265 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3287 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2553 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2564 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2575 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2542 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1830 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3298 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2597 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2586 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1863 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1852 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1841 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1885 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1896 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1874 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5190 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6819 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6808 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_70 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_81 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_182 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_171 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_160 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_92 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_193 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1104 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1115 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1126 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1159 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1148 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1137 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3040 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3051 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3095 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2350 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3062 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3084 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3073 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2361 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2372 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2383 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2394 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1671 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1660 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1693 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1682 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_2 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6605 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6616 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6638 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6627 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6649 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5926 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5915 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5904 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5959 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5948 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5937 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_929 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_918 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_907 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2191 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2180 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1490 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_406 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_417 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_439 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_428 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_3809 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7114 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7103 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7125 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6413 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6402 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5701 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6424 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6435 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6446 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5712 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5723 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6468 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5734 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5745 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6457 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6479 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5767 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5756 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5778 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5789 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_715 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_704 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_737 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_748 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_726 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6980 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6991 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_759 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_236 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_214 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_225 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_203 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_247 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_258 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_269 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5008 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5019 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4329 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4307 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4318 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3606 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3617 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2905 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2916 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3628 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3639 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2927 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2938 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2949 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6210 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6221 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6232 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6254 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6243 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5542 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5553 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5531 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6276 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6298 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6287 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6265 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5520 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5564 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5586 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4841 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4830 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5575 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4852 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4863 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4874 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5597 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4885 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4896 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_501 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_523 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_512 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_534 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_556 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_545 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_578 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_589 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_567 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_0 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4104 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4126 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4137 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4115 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3425 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3414 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3403 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4159 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4148 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2702 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2724 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2713 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3447 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3458 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3469 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3436 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2757 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2735 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2746 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2779 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2768 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6062 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6040 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6051 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6084 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6073 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6095 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5361 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5350 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5394 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5372 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5383 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4671 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4660 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4693 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4682 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3981 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3970 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3992 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_331 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_320 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_342 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_353 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_364 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_397 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_386 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_375 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2009 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1308 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1319 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3200 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3244 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3233 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3222 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3211 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2521 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3255 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2532 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2510 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3266 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3277 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3288 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2565 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2554 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2543 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3299 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1820 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2598 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2576 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2587 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1831 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1842 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1853 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1864 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1897 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1886 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1875 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5191 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5180 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4490 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6809 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_60 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_71 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_82 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_172 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_150 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_161 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_93 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_183 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_194 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1105 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1116 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1149 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1138 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1127 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3030 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3041 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3052 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2340 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3063 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3085 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3074 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3096 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2373 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2351 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2362 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2395 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2384 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1672 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1650 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1661 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1683 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1694 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_3 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6628 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6617 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6606 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6639 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5927 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5916 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5905 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5949 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5938 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_908 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_919 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2192 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2170 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2181 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1480 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1491 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_418 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_407 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_429 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_7115 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7104 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7126 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6403 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5702 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6425 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6436 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6447 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6414 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5713 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5724 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6469 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6458 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5735 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5746 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5757 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5768 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5779 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_705 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_738 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_716 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_727 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6970 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6981 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6992 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_749 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_204 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_215 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_226 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_237 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_259 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_248 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5009 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4308 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4319 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3607 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3618 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2906 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3629 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2917 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2939 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2928 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6200 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6211 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6233 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6222 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5510 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6255 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6244 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6277 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5543 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5532 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6288 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6266 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5521 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5576 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5565 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5554 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4842 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4820 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4831 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6299 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5587 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4853 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4864 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5598 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4875 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4886 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4897 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_513 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_502 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_546 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_557 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_524 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_535 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_579 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_568 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4105 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4127 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4116 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3426 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3415 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3404 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4149 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4138 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2703 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2714 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3448 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3459 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3437 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2736 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2747 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2758 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2725 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2769 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6030 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6052 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6063 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6041 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6074 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6085 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6096 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5351 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5340 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5395 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5362 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5373 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4650 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5384 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4672 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4661 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4683 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3971 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3982 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3960 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4694 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3993 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_310 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_321 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_365 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_343 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_354 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_332 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_376 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_387 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_398 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1309 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3201 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3234 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3223 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3212 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2522 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3245 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2500 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2511 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3267 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3256 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2533 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3289 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3278 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2555 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2544 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2566 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1810 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1821 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2599 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2577 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2588 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1832 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1854 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1843 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1887 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1865 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1876 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1898 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5170 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5181 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5192 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4480 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4491 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3790 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_72 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_50 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_61 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_140 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_162 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_83 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_173 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_94 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_151 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_195 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_184 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1106 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1117 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1128 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1139 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3020 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3031 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3042 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2341 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2330 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3064 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3053 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3086 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3075 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3097 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2374 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2352 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2363 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2396 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2385 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1651 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1662 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1640 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1673 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1695 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1684 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_4 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6607 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6618 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6629 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5917 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5906 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5928 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5939 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_909 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2160 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2171 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2182 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2193 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1481 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1470 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1492 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_408 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_419 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_7105 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7127 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7116 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6404 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6437 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6426 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6415 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5703 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5714 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5725 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5736 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6459 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6448 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5769 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5758 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5747 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6960 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_706 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_739 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_728 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_717 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6971 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6982 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6993 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_216 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_205 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_227 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_238 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_249 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4309 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3608 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2907 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3619 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2918 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2929 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6201 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6212 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6223 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6234 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6245 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5500 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6278 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5522 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5544 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5533 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5511 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6289 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6256 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6267 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4832 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5566 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5555 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4821 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5577 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4810 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4854 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4865 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4843 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5599 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5588 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4876 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4887 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4898 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_514 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_503 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6790 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_525 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_536 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_547 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_569 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_558 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4106 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4128 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4117 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3416 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3405 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4139 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2704 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2715 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3438 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3449 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3427 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2748 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2737 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2726 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2759 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6020 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6042 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6053 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6031 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6075 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6064 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6086 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6097 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5341 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5330 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5352 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4640 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5385 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5374 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5363 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5396 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4662 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4651 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4673 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4684 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3972 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3961 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3950 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4695 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3983 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3994 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_322 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_300 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_311 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_344 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_333 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_355 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_377 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_388 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_366 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_399 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3202 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3213 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3224 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2523 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3246 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3235 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2512 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2501 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3268 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3257 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2534 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3279 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2556 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2545 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1811 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1800 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2578 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2567 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2589 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1822 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1833 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1855 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1844 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1888 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1866 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1877 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1899 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5160 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5193 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5171 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5182 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4470 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4481 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4492 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3780 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3791 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_51 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_62 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_40 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_130 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_152 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_73 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_95 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_163 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_141 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_84 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_196 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_174 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_185 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1107 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1129 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1118 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3021 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3010 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3032 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3043 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2331 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2320 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3054 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3065 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3076 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3098 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2364 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2353 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2342 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3087 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1630 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2375 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2397 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2386 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1652 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1663 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1641 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1674 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1685 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1696 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_5 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6619 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6608 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5907 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5918 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5929 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2161 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2150 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2172 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2183 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2194 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1471 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1460 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1493 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1482 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_409 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_7106 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7128 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7117 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6416 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6438 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6427 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6405 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5704 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5715 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5726 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6449 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5759 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5737 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5748 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6950 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6961 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_718 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_729 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_707 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6972 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6983 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6994 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1290 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_206 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_217 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_228 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_239 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_3609 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2919 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2908 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6202 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6213 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6224 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6246 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6235 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5501 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6279 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5523 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5534 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5512 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6257 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6268 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4822 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5567 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4833 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5556 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5545 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5578 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4800 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4811 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4844 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4855 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4866 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5589 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4877 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4888 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4899 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_504 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6791 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6780 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_515 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_548 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_537 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_526 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_559 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4107 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4118 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3417 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3406 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4129 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2705 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3439 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3428 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2749 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2738 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2716 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2727 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6021 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6010 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6054 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6043 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6032 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6065 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6087 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6076 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5342 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5331 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5320 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6098 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5364 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5386 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4630 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4641 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5375 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5353 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5397 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4663 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4674 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4652 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3962 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3973 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3951 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3940 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4696 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4685 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3984 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3995 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_301 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_312 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_345 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_323 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_356 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_334 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_367 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_378 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_389 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3203 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3214 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3225 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3236 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3247 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2502 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2513 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3258 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_890 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2524 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2535 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3269 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2557 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2546 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1812 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1801 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2579 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2568 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1834 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1823 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1845 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1856 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1878 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1867 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1889 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5150 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5161 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5194 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5172 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5183 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4460 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4471 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4482 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3781 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3770 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4493 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3792 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_41 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_63 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_52 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_30 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_131 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_120 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_74 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_153 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_164 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_96 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_85 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_142 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_175 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_186 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_197 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1108 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1119 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3000 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3011 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3033 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3022 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2310 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2332 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2321 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3055 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3044 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3066 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3099 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2365 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2354 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2343 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3088 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3077 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1620 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2376 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2398 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2387 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1653 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1631 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1642 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1686 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1675 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1697 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1664 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_6 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4290 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6609 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5908 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5919 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2140 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2151 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2173 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2162 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2195 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1472 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1461 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2184 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1450 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1494 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1483 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7129 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7118 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7107 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6428 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6417 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6406 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5705 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5716 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5727 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6439 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5738 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5749 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6940 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6951 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_719 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_708 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6962 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6973 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6984 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6995 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1280 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1291 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_218 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_207 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_229 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_2909 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6203 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6214 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6225 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6236 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5524 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5535 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5502 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5513 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6247 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6258 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6269 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4823 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5568 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5557 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5546 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4801 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4812 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4845 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4856 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4834 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5579 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4867 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4889 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4878 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_505 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6781 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6792 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6770 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_516 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_538 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_527 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_549 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4119 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4108 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3407 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2706 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3429 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3418 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2739 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2728 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2717 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6011 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6000 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6044 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6022 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6033 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5310 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6055 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6066 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6088 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6077 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5343 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5321 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5332 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6099 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5376 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4631 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4620 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5354 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5365 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5398 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3930 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4664 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4675 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4653 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4642 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5387 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3963 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3952 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3941 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4686 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4697 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3996 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3985 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3974 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_302 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_313 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_346 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_324 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_335 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_379 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_368 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_357 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3204 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3215 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3248 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2514 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2503 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3226 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3237 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_880 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3259 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_891 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2525 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2536 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2547 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1802 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2569 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2558 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1835 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1824 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1813 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1846 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1857 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1879 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1868 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_390 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5151 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5140 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4450 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5173 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5162 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5184 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4461 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4472 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4483 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5195 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3771 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3760 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4494 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3793 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3782 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_20 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_42 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_53 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_31 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_121 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_110 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_154 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_75 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_64 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_97 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_132 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_143 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_86 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_187 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_198 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_176 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_165 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1109 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3012 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3001 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3034 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3023 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2322 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2300 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2311 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3067 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3056 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3045 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2333 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2355 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2344 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3089 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3078 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1621 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1610 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2366 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2399 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2377 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2388 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1632 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1654 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1643 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1687 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1665 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1676 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1698 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_7 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4280 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4291 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3590 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5909 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2130 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2163 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2152 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2174 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2141 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2196 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1451 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1462 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2185 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1440 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1484 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1473 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1495 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7119 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7108 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6418 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6407 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6429 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5706 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5717 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5728 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5739 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6941 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6930 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_709 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6952 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6963 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6974 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6985 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6996 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1270 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1292 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1281 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_208 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_219 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6204 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6215 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6226 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6237 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5525 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6248 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6259 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5514 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5503 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5569 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5547 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5536 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4824 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5558 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4802 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4813 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4846 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4857 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4835 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4868 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4879 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6782 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6771 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6793 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6760 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_506 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_517 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_528 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_539 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4109 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3408 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3419 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2729 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2707 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2718 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6001 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6012 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6045 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6023 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6034 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5300 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6067 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6056 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6078 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5322 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5333 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5311 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6089 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4632 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4610 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4621 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5366 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5377 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5344 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5355 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5399 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3920 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4643 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4654 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4665 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5388 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3964 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3953 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3931 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3942 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4676 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4687 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4698 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3986 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3997 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3975 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_303 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6590 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_347 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_336 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_314 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_325 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_369 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_358 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3216 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3205 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2504 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3227 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3249 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3238 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_870 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_881 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_892 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2526 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2537 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2515 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2548 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1803 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2559 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1825 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1814 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1836 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1858 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1847 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1869 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_380 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_391 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5130 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5152 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5141 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4440 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5185 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5174 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5163 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4462 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4473 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4451 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5196 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4484 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3772 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3761 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3750 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4495 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3794 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3783 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_10 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_100 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_43 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_54 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_122 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_111 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_21 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_32 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_76 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_65 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_155 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_87 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_133 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_144 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_188 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_98 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_177 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_166 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_199 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3002 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3013 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3024 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3035 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2323 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2301 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2312 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3057 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3046 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2334 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2356 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2345 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3068 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3079 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1600 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1611 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2367 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2378 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2389 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1633 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1622 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1644 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1688 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1666 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1677 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1655 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1699 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_8 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4270 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4281 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4292 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3580 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3591 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2890 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2131 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2120 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2164 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2153 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2142 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2197 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2175 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1430 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2186 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1452 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1441 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1463 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1485 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1496 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1474 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7109 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6419 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6408 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5707 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5718 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5729 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6942 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6931 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6920 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6953 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6964 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6975 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6986 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6997 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1271 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1260 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1293 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1282 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_209 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6205 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6216 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6227 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5526 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6249 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6238 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5515 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5504 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5537 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5548 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5559 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4803 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4814 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4836 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4825 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4847 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4858 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4869 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6750 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6783 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6772 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6761 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_507 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_518 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_529 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6794 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1090 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3409 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2708 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2719 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6002 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6024 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5301 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6035 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6013 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6046 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6079 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6068 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6057 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5323 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5334 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5312 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4622 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4611 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4600 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5367 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5345 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5356 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3921 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3910 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4655 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4666 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4633 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4644 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5389 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5378 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3954 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3932 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3943 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4677 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4699 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4688 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3987 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3965 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3976 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3998 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_304 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6580 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6591 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_337 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_326 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_315 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_348 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_359 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5890 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3206 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_860 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3228 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2505 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_871 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3239 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3217 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_893 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_882 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2527 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2516 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2538 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2549 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1815 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1826 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1837 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1804 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1848 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1859 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_381 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_370 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_392 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5131 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5120 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5142 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4441 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4430 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5164 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5153 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5175 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4463 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4474 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4452 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5197 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5186 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4485 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3751 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3740 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3762 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4496 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3795 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3784 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3773 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_11 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_101 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_44 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_33 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_22 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_112 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_77 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_55 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_66 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_88 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_145 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_134 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_123 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_167 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_189 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_178 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_99 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_156 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3014 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3003 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3025 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3036 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2302 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2313 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_690 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3047 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3058 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2324 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2335 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2346 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3069 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1601 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1612 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2357 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2368 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2379 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1634 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1623 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1645 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1678 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1667 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1656 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1689 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_9 DCDC_MUX$1_5/m1_336_3180# DCDC_CONV2TO1$1_9/m1_1082_1484# VPWR
+ VGND DCDC_MUX$1_7/m2_2834_0# DCDC_CONV2TO1$1_9/m1_738_1568# DCDC_CAP_UNIT$1_7109/m3_72_0#
+ DCDC_CAP_UNIT$1_7117/m3_72_0# clk1b clk0b DCDC_MUX$1_5/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4260 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4271 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4282 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3570 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3581 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4293 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3592 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2880 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2891 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2121 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2110 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2154 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2143 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2165 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1420 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2132 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2187 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2198 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2176 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1431 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1453 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1442 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1486 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1464 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1475 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1497 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4090 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6409 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5708 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5719 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6910 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6932 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6921 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6943 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6954 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6965 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6987 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6976 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6998 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1250 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1261 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1272 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1294 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1283 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6206 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6228 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6217 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6239 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5516 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5505 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5538 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5549 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5527 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4804 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4815 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4837 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4826 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4848 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4859 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6740 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6784 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6773 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6751 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6762 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_519 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_508 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6795 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1091 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1080 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2709 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_530 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6003 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6036 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6025 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6014 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6047 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6058 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6069 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5324 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5302 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5313 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5357 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5335 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4612 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4623 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4601 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5368 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5346 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3911 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3900 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4634 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4645 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4656 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5379 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3955 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3933 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3944 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3922 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4678 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4667 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4689 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3988 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3977 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3966 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3999 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6570 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6592 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6581 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_338 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_327 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_305 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_316 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_349 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5880 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5891 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3207 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_850 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3229 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3218 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_894 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_872 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_861 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_883 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2506 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2528 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2517 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2539 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1816 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1805 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1827 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1838 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1849 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_360 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_371 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_382 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_393 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5132 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5110 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5121 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5143 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4420 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4431 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5165 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5154 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5176 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4464 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4442 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4453 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3730 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5198 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5187 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4475 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4486 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3752 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3763 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3741 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4497 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3796 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3774 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3785 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_45 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_102 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_113 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_34 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_23 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_12 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7090 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_56 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_78 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_146 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_67 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_124 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_135 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_168 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_179 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_89 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_157 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3004 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3015 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3037 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3026 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2303 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2314 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_691 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_680 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3048 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2336 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2347 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2325 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3059 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1602 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2358 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2369 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1624 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1635 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1613 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1668 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1679 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1657 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1646 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_190 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4261 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4250 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4272 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4283 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3571 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3560 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4294 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3593 DCDC_CAP_UNIT$1_7131/m3_72_0# DCDC_CONV2TO1$1_66/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3582 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2870 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2881 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2892 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2100 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2122 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2111 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2155 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2144 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1410 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2133 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2188 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2177 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2166 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1432 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1421 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1443 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1454 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2199 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1487 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1476 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1465 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1498 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4091 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4080 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3390 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5709 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6900 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6911 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6933 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6922 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6944 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6955 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6966 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6977 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6988 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6999 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1262 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1251 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1240 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1273 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1284 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1295 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6207 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6218 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6229 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5517 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5506 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5539 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5528 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4805 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4838 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4827 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4816 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4849 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6730 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6741 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6763 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6774 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6752 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_509 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6796 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6785 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1070 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1081 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1092 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_8 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_520 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_531 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_6004 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6015 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6026 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6048 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6059 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6037 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5325 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5303 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5314 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5358 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5336 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4613 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4602 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5347 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3912 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3901 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4646 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4657 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4635 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4624 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5369 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3934 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3945 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3923 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4668 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4679 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3978 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3956 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3967 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3989 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6571 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6582 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_306 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_317 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_328 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6560 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_339 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5870 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5881 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6593 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5892 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_840 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_851 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3208 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3219 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_862 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_873 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_884 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2507 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2529 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2518 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_895 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1817 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1828 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1806 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1839 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_372 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_350 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_361 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_383 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_394 DCDC_MUX$1_9/m1_336_3180# DCDC_CAP_UNIT$1_5/c1_100_100# VPWR
+ VGND VOUT DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_5/m3_72_0#
+ clk1b clk0b DCDC_MUX$1_9/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_5100 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5111 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5133 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5122 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4410 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4432 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4421 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5144 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5166 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5155 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4465 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4454 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4443 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3720 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5177 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5199 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5188 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4476 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4487 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3742 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3731 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3753 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4498 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3797 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3786 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3764 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3775 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_103 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_35 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_24 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_13 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7080 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_7091 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_57 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_79 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_46 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_68 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_114 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_136 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_125 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6390 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_147 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_158 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_169 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3005 DCDC_CAP_UNIT$1_7121/m3_72_0# DCDC_CONV2TO1$1_88/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3016 DCDC_CAP_UNIT$1_7130/m3_72_0# DCDC_CONV2TO1$1_66/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3038 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3027 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2304 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_670 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_681 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_692 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3049 DCDC_CAP_UNIT$1_7129/m3_72_0# DCDC_CONV2TO1$1_84/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2315 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2337 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2326 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1603 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2348 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2359 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1625 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1636 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1614 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1669 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1647 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1658 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CONV2TO1$1_180 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CONV2TO1$1_191 DCDC_MUX$1_7/m1_336_3180# DCDC_CAP_UNIT$1_7101/c1_100_100# VPWR
+ VGND DCDC_MUX$1_9/m2_2834_0# DCDC_CONV2TO1$1_537/m1_738_1568# DCDC_CAP_UNIT$1_7085/m3_72_0#
+ DCDC_CAP_UNIT$1_7101/m3_72_0# clk1b clk0b DCDC_MUX$1_7/m1_2572_3264# clk0 clk1 DCDC_CONV2TO1$1
XDCDC_CAP_UNIT$1_4240 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4262 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4251 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4273 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3550 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3572 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3561 DCDC_CAP_UNIT$1_7125/m3_72_0# DCDC_CONV2TO1$1_88/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4295 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4284 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2860 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3594 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3583 DCDC_CAP_UNIT$1_7127/m3_72_0# DCDC_CONV2TO1$1_84/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2871 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2882 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2893 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2101 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2112 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2156 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2145 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1400 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2134 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1411 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2123 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2189 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2178 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2167 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1422 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1444 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1433 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1477 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1466 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1455 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1499 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1488 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4070 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4081 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4092 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3380 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_3391 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_2690 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6901 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6912 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6923 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6945 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6956 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6934 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6967 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6978 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6989 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1252 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1230 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1241 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1274 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1285 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1263 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_1296 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6208 DCDC_CAP_UNIT$1_9/m3_72_0# DCDC_CAP_UNIT$1_9/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_6219 DCDC_CAP_UNIT$1_5/m3_72_0# DCDC_CAP_UNIT$1_5/c1_100_100# DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5507 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5529 DCDC_CAP_UNIT$1_7117/m3_72_0# DCDC_CONV2TO1$1_9/m1_1082_1484#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4806 DCDC_CAP_UNIT$1_7101/m3_72_0# DCDC_CAP_UNIT$1_7101/c1_100_100#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_5518 DCDC_CAP_UNIT$1_7109/m3_72_0# DCDC_CONV2TO1$1_9/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4828 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4839 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
XDCDC_CAP_UNIT$1_4817 DCDC_CAP_UNIT$1_7085/m3_72_0# DCDC_CONV2TO1$1_537/m1_738_1568#
+ DCDC_CAP_UNIT$1
.ends

.subckt NOISE_INJECTION$2 D[3] D[0] D[1] D[2] bias_out Noise_in VSS
X0 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=2.6712e+12p pd=3.288e+07u as=3.528e+11p ps=4.2e+06u w=420000u l=150000u
X1 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 bias_out a_430_2231# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X4 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X5 Noise_in a_430_2231# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X6 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 bias_out a_430_5223# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X8 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X9 Noise_in a_430_5223# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X10 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X16 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 bias_out a_430_677# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X19 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 Noise_in a_430_677# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X23 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X27 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 bias_out a_430_3669# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X29 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X30 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 Noise_in a_430_3669# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
.ends

.subckt CCP_S_NMOS_B_5782581_X1_Y1_1653158393$1 a_147_525# a_835_525# a_200_252# a_241_1232#
+ a_230_525#
X0 a_200_252# a_230_525# a_835_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_835_525# a_230_525# a_200_252# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_230_525# a_200_252# a_147_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X3 a_147_525# a_200_252# a_230_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt CCP_PMOS_58853955_X1_Y1_1653158392$1 a_200_252# w_0_0# a_230_525#
X0 w_0_0# a_230_525# a_200_252# w_0_0# sky130_fd_pr__pfet_01v8 ad=3.402e+11p pd=4.14e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# w_0_0# w_0_0# sky130_fd_pr__pfet_01v8 ad=1.176e+11p pd=1.4e+06u as=0p ps=0u w=420000u l=150000u
X2 w_0_0# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_200_252# a_230_525# w_0_0# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt CMC_PMOS_23131506_X1_Y1_1653158394$1 a_402_525# a_200_252# w_0_0# a_230_525#
X0 w_0_0# a_200_252# a_402_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=3.402e+11p pd=4.14e+06u as=1.176e+11p ps=1.4e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# w_0_0# w_0_0# sky130_fd_pr__pfet_01v8 ad=1.176e+11p pd=1.4e+06u as=0p ps=0u w=420000u l=150000u
X2 w_0_0# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_402_525# a_200_252# w_0_0# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt DP_NMOS_B_93310865_X1_Y1_1653158395$1 a_402_525# a_372_252# a_147_525# a_200_252#
+ a_241_1232# a_230_525#
X0 a_402_525# a_372_252# a_147_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=3.402e+11p ps=4.14e+06u w=420000u l=150000u
X1 a_147_525# a_372_252# a_402_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_230_525# a_200_252# a_147_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=0p ps=0u w=420000u l=150000u
X3 a_147_525# a_200_252# a_230_525# a_241_1232# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt NMOS_S_93862694_X1_Y1_1653158396$1 a_200_252# a_230_483# a_147_483#
X0 a_230_483# a_200_252# a_147_483# a_147_483# sky130_fd_pr__nfet_01v8 ad=2.352e+11p pd=2.24e+06u as=4.452e+11p ps=4.42e+06u w=840000u l=150000u
X1 a_147_483# a_200_252# a_230_483# a_147_483# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
.ends

.subckt DCDC_COMP$1 VIN VIP VGND CLK VOP VPWR
XCCP_S_NMOS_B_5782581_X1_Y1_1653158393$1_0 m1_2343_2456# m1_1655_2540# m1_1311_2036#
+ VGND VOP CCP_S_NMOS_B_5782581_X1_Y1_1653158393$1
XCCP_PMOS_58853955_X1_Y1_1653158392$1_0 m1_1311_2036# VPWR VOP CCP_PMOS_58853955_X1_Y1_1653158392$1
XCMC_PMOS_23131506_X1_Y1_1653158394$1_0 m1_1311_2036# CLK VPWR VOP CMC_PMOS_23131506_X1_Y1_1653158394$1
XCMC_PMOS_23131506_X1_Y1_1653158394$1_1 m1_2343_2456# CLK VPWR m1_1655_2540# CMC_PMOS_23131506_X1_Y1_1653158394$1
XDP_NMOS_B_93310865_X1_Y1_1653158395$1_0 m1_1655_2540# VIP li_2318_3811# VIN VGND
+ m1_2343_2456# DP_NMOS_B_93310865_X1_Y1_1653158395$1
XNMOS_S_93862694_X1_Y1_1653158396$1_0 CLK li_2318_3811# VGND NMOS_S_93862694_X1_Y1_1653158396$1
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_RRZ644$2 c1_n842_n760# m3_n870_n788#
X0 c1_n842_n760# m3_n870_n788# sky130_fd_pr__cap_mim_m3_1 l=8e+06u w=8e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_F8PC2Z$2 m3_n550_n300# c1_n450_n220#
X0 c1_n450_n220# m3_n550_n300# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=4e+06u
.ends

.subckt NMOS_S_22639876_X1_Y1_1653520174$2 a_147_525# a_200_252# a_230_525#
X0 a_230_525# a_200_252# a_147_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_147_525# a_200_252# a_230_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_K8PL49$1$2 c1_n442_n400# m3_n470_n428#
X0 c1_n442_n400# m3_n470_n428# sky130_fd_pr__cap_mim_m3_1 l=4e+06u w=4e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_FJFAMD$2 c1_n250_n200# m3_n291_n340#
X0 c1_n250_n200# m3_n291_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt PMOS_4T_48942251_X2_Y1_1653520168_1653520173$2 a_147_525# a_200_252# w_0_0#
+ a_230_525#
X0 a_147_525# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=3.402e+11p pd=4.14e+06u as=2.352e+11p ps=2.8e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# a_147_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_147_525# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_230_525# a_200_252# a_147_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt NMOS_S_22639876_X1_Y1_1653520167_1653520173$2 a_147_525# a_200_252# a_230_525#
X0 a_230_525# a_200_252# a_147_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_147_525# a_200_252# a_230_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt INV_B_13409687_0_1653520173$2 PMOS_4T_48942251_X2_Y1_1653520168_1653520173$2_0/w_0_0#
+ PMOS_4T_48942251_X2_Y1_1653520168_1653520173$2_0/a_147_525# m1_430_896# m1_430_56#
+ VSUBS
XPMOS_4T_48942251_X2_Y1_1653520168_1653520173$2_0 PMOS_4T_48942251_X2_Y1_1653520168_1653520173$2_0/a_147_525#
+ m1_430_896# PMOS_4T_48942251_X2_Y1_1653520168_1653520173$2_0/w_0_0# m1_430_56# PMOS_4T_48942251_X2_Y1_1653520168_1653520173$2
XNMOS_S_22639876_X1_Y1_1653520167_1653520173$2_0 VSUBS m1_430_896# m1_430_56# NMOS_S_22639876_X1_Y1_1653520167_1653520173$2
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_4VD94C$1$2 c1_n1650_n792# m3_n1750_n820#
X0 c1_n1650_n792# m3_n1750_n820# sky130_fd_pr__cap_mim_m3_1 l=8e+06u w=1.6e+07u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_4CW8F2$2 c1_n842_n376# m3_n870_n410#
X0 c1_n842_n376# m3_n870_n410# sky130_fd_pr__cap_mim_m3_1 l=4e+06u w=8e+06u
.ends

.subckt DCDC_DAC$2 RST VOUT D1 D4 D3 D5 D2 D0 VPWR m4_656_641# VGND
XC8_8 VOUT m1_3830_5595# sky130_fd_pr__cap_mim_m3_1_RRZ644$2
XC4_2 m1_3824_2469# VOUT sky130_fd_pr__cap_mim_m3_1_F8PC2Z$2
XNMOS_S_22639876_X1_Y1_1653520174$2_0 VGND RST VOUT NMOS_S_22639876_X1_Y1_1653520174$2
XC4_4 VOUT m1_2436_3089# sky130_fd_pr__cap_mim_m3_1_K8PL49$1$2
XC2_2 VOUT VGND sky130_fd_pr__cap_mim_m3_1_FJFAMD$2
XINV_B_13409687_0_1653520173$2_0 VPWR VPWR D0 m1_2452_2549# VGND INV_B_13409687_0_1653520173$2
XINV_B_13409687_0_1653520173$2_1 VPWR VPWR D3 m1_3830_3805# VGND INV_B_13409687_0_1653520173$2
XINV_B_13409687_0_1653520173$2_3 VPWR VPWR D5 m1_2470_5595# VGND INV_B_13409687_0_1653520173$2
XINV_B_13409687_0_1653520173$2_2 VPWR VPWR D4 m1_3830_5595# VGND INV_B_13409687_0_1653520173$2
XINV_B_13409687_0_1653520173$2_4 VPWR VPWR D2 m1_2436_3089# VGND INV_B_13409687_0_1653520173$2
XINV_B_13409687_0_1653520173$2_5 VPWR VPWR D1 m1_3824_2469# VGND INV_B_13409687_0_1653520173$2
Xsky130_fd_pr__cap_mim_m3_1_4VD94C$1$2_0 VOUT m1_2470_5595# sky130_fd_pr__cap_mim_m3_1_4VD94C$1$2
Xsky130_fd_pr__cap_mim_m3_1_FJFAMD$2_0 VOUT m1_2452_2549# sky130_fd_pr__cap_mim_m3_1_FJFAMD$2
Xsky130_fd_pr__cap_mim_m3_1_4CW8F2$2_0 VOUT m1_3830_3805# sky130_fd_pr__cap_mim_m3_1_4CW8F2$2
.ends

.subckt DCDC_FF$1 VNB VPB D CLK Q
X0 VPB a_n15141_427# a_n15212_453# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.02105e+12p pd=9.61e+06u as=2.19e+11p ps=2.15e+06u w=750000u l=150000u
X1 a_n15632_427# a_n15348_427# a_n15413_453# VNB sky130_fd_pr__nfet_01v8 ad=1.368e+11p pd=1.48e+06u as=1.32e+11p ps=1.49e+06u w=360000u l=150000u
X2 a_n15141_427# a_n15341_727# a_n14992_453# VNB sky130_fd_pr__nfet_01v8 ad=1.242e+11p pd=1.41e+06u as=1.392e+11p ps=1.53e+06u w=360000u l=150000u
X3 VPB a_n15348_427# a_n15341_727# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X4 VNB a_n15728_605# Q VNB sky130_fd_pr__nfet_01v8 ad=7.492e+11p pd=8.11e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X5 a_n15348_427# CLK VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X6 a_n15212_453# a_n15341_727# a_n15632_427# VNB sky130_fd_pr__nfet_01v8 ad=1.978e+11p pd=1.99e+06u as=0p ps=0u w=360000u l=150000u
X7 a_n15141_427# a_n15348_427# a_n14965_819# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.365e+11p pd=1.49e+06u as=1.533e+11p ps=1.57e+06u w=420000u l=150000u
X8 a_n15728_605# a_n15632_427# VNB VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X9 VPB a_n15728_605# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X10 VNB a_n15141_427# a_n15212_453# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X11 a_n14992_453# a_n15212_453# VNB VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 a_n15728_605# a_n15632_427# VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=0p ps=0u w=1e+06u l=150000u
X13 VNB a_n15348_427# a_n15341_727# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
X14 a_n14794_453# a_n15341_727# a_n15141_427# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.155e+11p pd=1.39e+06u as=0p ps=0u w=420000u l=150000u
X15 a_n14965_819# a_n15212_453# VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X16 a_n14794_453# a_n15348_427# a_n15141_427# VNB sky130_fd_pr__nfet_01v8 ad=1.626e+11p pd=1.66e+06u as=0p ps=0u w=360000u l=150000u
X17 a_n15632_427# a_n15341_727# a_n15390_819# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.134e+11p pd=1.38e+06u as=1.764e+11p ps=1.68e+06u w=420000u l=150000u
X18 a_n15348_427# CLK VNB VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X19 a_n15212_453# a_n15348_427# a_n15632_427# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 VPB D a_n14794_453# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 a_n15390_819# a_n15728_605# VPB VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 VNB D a_n14794_453# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 a_n15413_453# a_n15728_605# VNB VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt top_level$1 clk config_in[0] config_in[1] config_in[2] config_in[3] config_in[4]
+ config_in[5] noise_D[3] noise_D[2] noise_D[1] noise_D[0] DAC_RST VREF_out D[1] D[3]
+ D[4] D[2] D[0] D[5] VREF_in Noise_in VOUT clk_noise non_clk_rst_n non_clk_control
+ VPWR VGND
XDCDC_INVERTER$1_0 VGND VPWR DCDC_FF$1_0/Q DCDC_FF$1_0/D DCDC_INVERTER$1
Xdcdc_config$1_0 VPWR config_in[0] config_in[1] config_in[2] config_in[3] config_in[4]
+ config_in[5] dcdc_config$1_0/s[0] dcdc_config$1_0/s[10] dcdc_config$1_0/s[11] dcdc_config$1_0/s[1]
+ dcdc_config$1_0/s[2] dcdc_config$1_0/s[3] dcdc_config$1_0/s[4] dcdc_config$1_0/s[5]
+ dcdc_config$1_0/s[6] dcdc_config$1_0/s[7] dcdc_config$1_0/s[8] dcdc_config$1_0/s[9]
+ VGND dcdc_config$1
XNON_CLK_GEN$1_0 clk_noise DCDC_FF$1_0/D NON_CLK_GEN$1_0/clk0 NON_CLK_GEN$1_0/clk0b
+ NON_CLK_GEN$1_0/clk1 NON_CLK_GEN$1_0/clk1b non_clk_control non_clk_rst_n VPWR VGND
+ NON_CLK_GEN$1
XDCDC_CLKGATE$1_0 VGND VPWR clk DCDC_FF$1_0/CLK DCDC_COMP$1_0/VOP DCDC_CLKGATE$1
Xsix_stage_conv$1_0 NON_CLK_GEN$1_0/clk0b NON_CLK_GEN$1_0/clk1b NON_CLK_GEN$1_0/clk1
+ NON_CLK_GEN$1_0/clk0 dcdc_config$1_0/s[0] dcdc_config$1_0/s[1] dcdc_config$1_0/s[2]
+ dcdc_config$1_0/s[3] dcdc_config$1_0/s[4] dcdc_config$1_0/s[5] dcdc_config$1_0/s[6]
+ dcdc_config$1_0/s[7] dcdc_config$1_0/s[8] dcdc_config$1_0/s[9] dcdc_config$1_0/s[10]
+ dcdc_config$1_0/s[11] VPWR VOUT VGND six_stage_conv$1
XNOISE_INJECTION$2_0 noise_D[3] noise_D[0] noise_D[1] noise_D[2] VREF_in Noise_in
+ VGND NOISE_INJECTION$2
XDCDC_COMP$1_0 VOUT VREF_in VGND DCDC_COMP$1_0/CLK DCDC_COMP$1_0/VOP VPWR DCDC_COMP$1
XDCDC_DAC$2_0 DAC_RST VREF_out D[1] D[4] D[3] D[5] D[2] D[0] DCDC_DAC$2_0/VPWR VPWR
+ VGND DCDC_DAC$2
XDCDC_FF$1_0 VGND VPWR DCDC_FF$1_0/D DCDC_FF$1_0/CLK DCDC_FF$1_0/Q DCDC_FF$1
.ends

.subckt PMU$1 VSUBS
X2fF_decap$1_0[0] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_0[1] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_0[2] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_0[3] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_0[4] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_1[0] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_1[1] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_1[2] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_1[3] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_1[4] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_2[0] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_2[1] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_2[2] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_2[3] top_level$1_0/VPWR VSUBS x2fF_decap$1
X2fF_decap$1_2[4] top_level$1_0/VPWR VSUBS x2fF_decap$1
Xtop_level$1_0 top_level$1_0/clk top_level$1_0/config_in[0] top_level$1_0/config_in[1]
+ top_level$1_0/config_in[2] top_level$1_0/config_in[3] top_level$1_0/config_in[4]
+ top_level$1_0/config_in[5] top_level$1_0/noise_D[3] top_level$1_0/noise_D[2] top_level$1_0/noise_D[1]
+ top_level$1_0/noise_D[0] top_level$1_0/DAC_RST top_level$1_0/VREF_out top_level$1_0/D[1]
+ top_level$1_0/D[3] top_level$1_0/D[4] top_level$1_0/D[2] top_level$1_0/D[0] top_level$1_0/D[5]
+ top_level$1_0/VREF_in top_level$1_0/Noise_in top_level$1_0/VOUT top_level$1_0/clk_noise
+ top_level$1_0/non_clk_rst_n top_level$1_0/non_clk_control top_level$1_0/VPWR VSUBS
+ top_level$1
.ends

.subckt sky130_fd_pr__pfet_01v8_UGG56J$1 a_n73_n10000# a_15_n10000# w_n211_n10219#
+ a_n33_n10097#
X0 a_15_n10000# a_n33_n10097# a_n73_n10000# w_n211_n10219# sky130_fd_pr__pfet_01v8 ad=3.6e+13p pd=2.0072e+08u as=2.9e+13p ps=2.0058e+08u w=1e+08u l=150000u
.ends

.subckt BIG_PMOS$1
XBIG_PMOS m1_12219_232# m1_12219_n1955# li_266_352# m1_36_n9955# sky130_fd_pr__pfet_01v8_UGG56J$1
.ends

.subckt pwell$1
.ends

.subckt poly$1
.ends

.subckt NOISE_INJECTION$1$1 D[3] D[0] D[1] D[2] bias_out Noise_in VSS
X0 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=2.6712e+12p pd=3.288e+07u as=3.528e+11p ps=4.2e+06u w=420000u l=150000u
X1 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 VSS D[1] a_430_3669# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 bias_out a_430_2231# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X4 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X5 Noise_in a_430_2231# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X6 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X7 bias_out a_430_5223# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X8 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X9 Noise_in a_430_5223# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X10 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 a_430_5223# D[0] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 VSS D[0] a_430_5223# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=3.528e+11p pd=4.2e+06u as=0p ps=0u w=420000u l=150000u
X16 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X17 a_430_2231# D[2] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 bias_out a_430_677# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X19 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 VSS D[2] a_430_2231# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X22 Noise_in a_430_677# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X23 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X24 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 a_430_677# D[3] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X27 VSS D[3] a_430_677# VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 bias_out a_430_3669# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
X29 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X30 a_430_3669# D[1] VSS VSS sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 Noise_in a_430_3669# sky130_fd_pr__cap_mim_m3_1 l=3.4e+06u w=4e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_4CW8F2$1$1 c1_n842_n376# m3_n870_n410#
X0 c1_n842_n376# m3_n870_n410# sky130_fd_pr__cap_mim_m3_1 l=4e+06u w=8e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_RRZ644$1$1 c1_n842_n760# m3_n870_n788#
X0 c1_n842_n760# m3_n870_n788# sky130_fd_pr__cap_mim_m3_1 l=8e+06u w=8e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_FJFAMD$1$1 c1_n250_n200# m3_n291_n340#
X0 c1_n250_n200# m3_n291_n340# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=2e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_F8PC2Z$1$1 m3_n550_n300# c1_n450_n220#
X0 c1_n450_n220# m3_n550_n300# sky130_fd_pr__cap_mim_m3_1 l=2e+06u w=4e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_K8PL49$1$1$1 c1_n442_n400# m3_n470_n428#
X0 c1_n442_n400# m3_n470_n428# sky130_fd_pr__cap_mim_m3_1 l=4e+06u w=4e+06u
.ends

.subckt PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1$1 a_147_525# a_200_252# w_0_0#
+ a_230_525#
X0 a_147_525# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=3.402e+11p pd=4.14e+06u as=2.352e+11p ps=2.8e+06u w=420000u l=150000u
X1 a_230_525# a_200_252# a_147_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X2 a_147_525# a_200_252# a_230_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X3 a_230_525# a_200_252# a_147_525# w_0_0# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt NMOS_S_22639876_X1_Y1_1653520167_1653520173$1$1 a_147_525# a_200_252# a_230_525#
X0 a_230_525# a_200_252# a_147_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_147_525# a_200_252# a_230_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt INV_B_13409687_0_1653520173$1$1 PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1$1_0/w_0_0#
+ PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1$1_0/a_147_525# m1_430_56# m1_430_896#
+ VSUBS
XPMOS_4T_48942251_X2_Y1_1653520168_1653520173$1$1_0 PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1$1_0/a_147_525#
+ m1_430_896# PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1$1_0/w_0_0# m1_430_56#
+ PMOS_4T_48942251_X2_Y1_1653520168_1653520173$1$1
XNMOS_S_22639876_X1_Y1_1653520167_1653520173$1$1_0 VSUBS m1_430_896# m1_430_56# NMOS_S_22639876_X1_Y1_1653520167_1653520173$1$1
.ends

.subckt NMOS_S_22639876_X1_Y1_1653520174$1$1 a_147_525# a_200_252# a_230_525#
X0 a_230_525# a_200_252# a_147_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=1.176e+11p pd=1.4e+06u as=2.226e+11p ps=2.74e+06u w=420000u l=150000u
X1 a_147_525# a_200_252# a_230_525# a_147_525# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_4VD94C$1$1$1 c1_n1650_n792# m3_n1750_n820#
X0 c1_n1650_n792# m3_n1750_n820# sky130_fd_pr__cap_mim_m3_1 l=8e+06u w=1.6e+07u
.ends

.subckt DCDC_DAC$1$1 RST VOUT D1 D4 D3 D5 D2 D0 VPWR m4_656_641# VGND
Xsky130_fd_pr__cap_mim_m3_1_4CW8F2$1$1_0 VOUT m1_3830_3805# sky130_fd_pr__cap_mim_m3_1_4CW8F2$1$1
XC8_8 VOUT m1_3830_5595# sky130_fd_pr__cap_mim_m3_1_RRZ644$1$1
Xsky130_fd_pr__cap_mim_m3_1_FJFAMD$1$1_0 VOUT m1_2452_2549# sky130_fd_pr__cap_mim_m3_1_FJFAMD$1$1
XC4_2 m1_3824_2469# VOUT sky130_fd_pr__cap_mim_m3_1_F8PC2Z$1$1
XC4_4 VOUT m1_2436_3089# sky130_fd_pr__cap_mim_m3_1_K8PL49$1$1$1
XC2_2 VOUT VGND sky130_fd_pr__cap_mim_m3_1_FJFAMD$1$1
XINV_B_13409687_0_1653520173$1$1_0 VPWR VPWR m1_2452_2549# D0 VGND INV_B_13409687_0_1653520173$1$1
XNMOS_S_22639876_X1_Y1_1653520174$1$1_0 VGND RST VOUT NMOS_S_22639876_X1_Y1_1653520174$1$1
XINV_B_13409687_0_1653520173$1$1_1 VPWR VPWR m1_3830_3805# D3 VGND INV_B_13409687_0_1653520173$1$1
XINV_B_13409687_0_1653520173$1$1_2 VPWR VPWR m1_3830_5595# D4 VGND INV_B_13409687_0_1653520173$1$1
XINV_B_13409687_0_1653520173$1$1_3 VPWR VPWR m1_2470_5595# D5 VGND INV_B_13409687_0_1653520173$1$1
XINV_B_13409687_0_1653520173$1$1_5 VPWR VPWR m1_3824_2469# D1 VGND INV_B_13409687_0_1653520173$1$1
XINV_B_13409687_0_1653520173$1$1_4 VPWR VPWR m1_2436_3089# D2 VGND INV_B_13409687_0_1653520173$1$1
Xsky130_fd_pr__cap_mim_m3_1_4VD94C$1$1$1_0 VOUT m1_2470_5595# sky130_fd_pr__cap_mim_m3_1_4VD94C$1$1$1
.ends

.subckt DAC_NOISE$1 VSUBS
XNOISE_INJECTION$1$1_0 NOISE_INJECTION$1$1_0/D[3] NOISE_INJECTION$1$1_0/D[0] NOISE_INJECTION$1$1_0/D[1]
+ NOISE_INJECTION$1$1_0/D[2] NOISE_INJECTION$1$1_0/bias_out NOISE_INJECTION$1$1_0/Noise_in
+ VSUBS NOISE_INJECTION$1$1
XDCDC_DAC$1$1_0 DCDC_DAC$1$1_0/RST DCDC_DAC$1$1_0/VOUT DCDC_DAC$1$1_0/D1 DCDC_DAC$1$1_0/D4
+ DCDC_DAC$1$1_0/D3 DCDC_DAC$1$1_0/D5 DCDC_DAC$1$1_0/D2 DCDC_DAC$1$1_0/D0 DCDC_DAC$1$1_0/VPWR
+ m4_18449_8000# VSUBS DCDC_DAC$1$1
.ends

.subckt n+poly$1
R0 a_40100_43000# a_74100_43000# sky130_fd_pr__res_generic_po w=1.65e+07u l=1.545e+08u
R1 a_6000_27000# a_12000_27000# sky130_fd_pr__res_generic_po w=8.5e+06u l=1.35e+07u
R2 a_12000_75000# a_24000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R3 a_12000_27000# a_22000_27000# sky130_fd_pr__res_generic_po w=8.5e+06u l=3.35e+07u
R4 a_0_75000# a_12000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R5 a_60000_75000# a_72000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R6 a_2000_27000# a_2000_27000# sky130_fd_pr__res_generic_po w=1e+06u l=1.05e+07u
R7 a_2000_27000# a_6000_27000# sky130_fd_pr__res_generic_po w=8.5e+06u l=3.5e+06u
R8 a_24000_75000# a_36000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R9 a_40000_11000# a_74000_11000# sky130_fd_pr__res_generic_po w=7.5e+06u l=1.535e+08u
R10 a_72000_75000# a_72000_75000# sky130_fd_pr__res_generic_po w=1e+06u l=4.05e+07u
R11 a_22000_27000# a_40000_27000# sky130_fd_pr__res_generic_po w=8.5e+06u l=7.35e+07u
R12 a_74000_27000# a_74000_27000# sky130_fd_pr__res_generic_po w=1e+06u l=3.05e+07u
R13 a_6100_43000# a_12100_43000# sky130_fd_pr__res_generic_po w=1.65e+07u l=1.45e+07u
R14 a_12100_59000# a_24100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R15 a_12100_90000# a_24100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
R16 a_36000_75000# a_48000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R17 a_2100_43000# a_2100_43000# sky130_fd_pr__res_generic_po w=5e+06u l=1.55e+07u
R18 a_12100_43000# a_22100_43000# sky130_fd_pr__res_generic_po w=1.65e+07u l=3.45e+07u
R19 a_0_59000# a_12100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R20 a_60100_59000# a_72100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R21 a_2100_43000# a_6100_43000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.5e+06u
R22 a_0_90000# a_12100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
R23 a_60100_90000# a_72100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
R24 a_24100_59000# a_36100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R25 a_24100_90000# a_36100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
R26 a_48000_75000# a_60000_75000# sky130_fd_pr__res_generic_po w=8.5e+06u l=4.35e+07u
R27 a_74100_43000# a_74100_43000# sky130_fd_pr__res_generic_po w=5e+06u l=3.55e+07u
R28 a_6000_11000# a_12000_11000# sky130_fd_pr__res_generic_po w=8e+06u l=1.35e+07u
R29 a_72100_59000# a_72100_59000# sky130_fd_pr__res_generic_po w=5e+06u l=4.55e+07u
R30 a_22100_43000# a_40100_43000# sky130_fd_pr__res_generic_po w=1.65e+07u l=7.45e+07u
R31 a_74000_11000# a_74000_11000# sky130_fd_pr__res_generic_po w=250000u l=3.025e+07u
R32 a_72100_90000# a_72100_90000# sky130_fd_pr__res_generic_po w=2e+07u l=6.05e+07u
R33 a_12000_11000# a_22000_11000# sky130_fd_pr__res_generic_po w=8e+06u l=3.35e+07u
R34 a_2000_11000# a_2000_11000# sky130_fd_pr__res_generic_po w=750000u l=1.025e+07u
R35 a_2000_11000# a_6000_11000# sky130_fd_pr__res_generic_po w=8e+06u l=3.5e+06u
R36 a_36100_59000# a_48100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R37 a_36100_90000# a_48100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
R38 a_40000_27000# a_74000_27000# sky130_fd_pr__res_generic_po w=8.5e+06u l=1.535e+08u
R39 a_22000_11000# a_40000_11000# sky130_fd_pr__res_generic_po w=8e+06u l=7.35e+07u
R40 a_48100_59000# a_60100_59000# sky130_fd_pr__res_generic_po w=1.65e+07u l=4.45e+07u
R41 a_48100_90000# a_60100_90000# sky130_fd_pr__res_generic_po w=4.65e+07u l=4.45e+07u
.ends

.subckt pdiff$1
.ends

.subckt TOP VSUBS
XM1T1R_2T1R_nmos_pmos$1_0 VSUBS M1T1R_2T1R_nmos_pmos$1
XGWU_Adamlab$1_0 VSUBS GWU_Adamlab$1
Xnwell$1_0 nwell$1
Xhall_mosfet$1_0 VSUBS hall_mosfet$1
Xhall_mosfet$1_1 VSUBS hall_mosfet$1
Xndiff$1_0 ndiff$1
XPMU$1_0 VSUBS PMU$1
XBIG_PMOS$1_0 BIG_PMOS$1
XBIG_PMOS$1_1 BIG_PMOS$1
XBIG_PMOS$1_2 BIG_PMOS$1
XBIG_PMOS$1_3 BIG_PMOS$1
Xpwell$1_0 pwell$1
XBIG_PMOS$1_4 BIG_PMOS$1
XBIG_PMOS$1_5 BIG_PMOS$1
Xpoly$1_0 poly$1
XBIG_PMOS$1_6 BIG_PMOS$1
XBIG_PMOS$1_7 BIG_PMOS$1
XDAC_NOISE$1_0 VSUBS DAC_NOISE$1
XDAC_NOISE$1_1 VSUBS DAC_NOISE$1
Xn+poly$1_0 n+poly$1
XDAC_NOISE$1_2 VSUBS DAC_NOISE$1
Xpdiff$1_0 pdiff$1
XDAC_NOISE$1_3 VSUBS DAC_NOISE$1
.ends

.subckt user_analog_project_wrapper wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0] wbs_adr_i[10]
+ wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15] wbs_adr_i[16]
+ wbs_adr_i[17] wbs_adr_i[1] wbs_adr_i[2] wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6]
+ wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9] wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11]
+ wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14] wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[1]
+ wbs_dat_i[2] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[1] wbs_dat_o[2] wbs_dat_o[3]
+ wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6] wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0]
+ wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3] wbs_stb_i wbs_we_i wbs_dat_i[17] wbs_dat_i[18]
+ wbs_dat_i[19] wbs_adr_i[18] wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23]
+ wbs_dat_i[24] wbs_dat_i[25] wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29]
+ wbs_adr_i[19] wbs_dat_i[30] wbs_dat_i[31] la_oenb[0] wbs_adr_i[20] wbs_adr_i[21]
+ wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26] wbs_adr_i[27]
+ wbs_adr_i[28] wbs_adr_i[29] la_oenb[1] wbs_adr_i[30] wbs_adr_i[31] la_oenb[2] wbs_dat_o[17]
+ wbs_dat_o[18] wbs_dat_o[19] la_oenb[3] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22]
+ wbs_dat_o[23] wbs_dat_o[24] wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28]
+ wbs_dat_o[29] la_oenb[4] wbs_dat_o[30] wbs_dat_o[31] la_oenb[5] la_data_in[0] la_data_in[1]
+ la_data_in[2] la_data_in[3] la_data_in[4] la_data_in[5] la_data_out[0] la_data_out[1]
+ la_data_out[2] la_data_out[3] la_data_out[4] la_data_out[5] la_data_in[23] la_data_in[24]
+ la_data_in[25] la_oenb[6] la_oenb[7] la_oenb[8] la_oenb[9] la_data_in[26] la_data_in[11]
+ la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[6] la_data_in[7] la_data_in[8]
+ la_data_in[9] la_data_in[15] la_data_out[10] la_data_out[11] la_data_out[12] la_data_out[13]
+ la_data_out[14] la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18]
+ la_data_out[19] la_data_in[16] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23]
+ la_data_out[24] la_data_out[25] la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[10]
+ la_data_out[6] la_data_out[7] la_data_out[8] la_data_out[9] la_data_in[20] la_oenb[10]
+ la_oenb[11] la_oenb[12] la_oenb[13] la_oenb[14] la_oenb[15] la_oenb[16] la_oenb[17]
+ la_oenb[18] la_oenb[19] la_data_in[21] la_oenb[20] la_oenb[21] la_oenb[22] la_oenb[23]
+ la_oenb[24] la_oenb[25] la_data_in[22] la_data_in[39] la_oenb[45] la_data_in[40]
+ la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29] la_data_in[41] la_data_out[30]
+ la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34] la_data_out[35]
+ la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39] la_data_in[42] la_data_out[40]
+ la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44] la_data_out[45]
+ la_data_out[46] la_data_in[43] la_data_in[44] la_data_in[45] la_data_in[46] la_oenb[46]
+ la_oenb[38] la_oenb[39] la_oenb[37] la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43]
+ la_data_in[27] la_data_in[28] la_data_in[29] la_oenb[44] la_data_in[30] la_data_in[31]
+ la_data_in[32] la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37]
+ la_oenb[26] la_oenb[27] la_oenb[28] la_oenb[29] la_data_in[38] la_oenb[30] la_oenb[31]
+ la_oenb[32] la_oenb[33] la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[47] la_oenb[48]
+ la_oenb[49] la_oenb[50] la_oenb[51] la_oenb[52] la_oenb[53] la_oenb[54] la_oenb[55]
+ la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59] la_oenb[60] la_oenb[61] la_oenb[62]
+ la_oenb[63] la_oenb[64] la_oenb[65] la_oenb[66] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54] la_data_in[55]
+ la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[60] la_data_in[61]
+ la_data_in[62] la_data_in[63] la_data_out[47] la_data_out[48] la_data_out[49] la_data_in[64]
+ la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_in[65] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_in[66] la_data_in[67] la_data_in[72]
+ la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76] la_data_in[77] la_data_in[78]
+ la_data_in[79] la_data_in[80] la_data_in[81] la_data_in[82] la_data_in[83] la_data_in[84]
+ la_data_in[85] la_data_in[86] la_data_in[87] la_data_in[69] la_oenb[67] la_oenb[68]
+ la_oenb[69] la_oenb[70] la_oenb[71] la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75]
+ la_oenb[76] la_oenb[77] la_oenb[78] la_oenb[79] la_oenb[80] la_oenb[81] la_oenb[82]
+ la_oenb[83] la_oenb[84] la_oenb[85] la_oenb[86] la_oenb[87] la_data_out[68] la_data_out[69]
+ la_data_in[70] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_in[71] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_in[68] la_oenb[88] la_oenb[89]
+ la_oenb[90] la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96]
+ la_oenb[97] la_oenb[98] la_oenb[99] la_data_in[101] la_data_in[102] la_data_in[103]
+ la_data_in[104] la_data_in[105] la_data_in[106] la_data_in[107] la_data_in[108]
+ la_data_in[100] la_data_in[90] la_data_in[91] la_data_in[92] la_data_in[93] la_data_in[94]
+ la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98] la_data_in[99] la_data_out[100]
+ la_data_out[101] la_data_out[102] la_data_out[103] la_data_out[104] la_data_out[105]
+ la_data_out[93] la_data_out[106] la_data_out[94] la_data_out[107] la_data_out[95]
+ la_data_out[96] la_data_out[108] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[92] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_data_in[88] la_data_in[89] la_data_out[88]
+ la_data_out[89] la_data_out[90] la_data_out[91] la_data_in[119] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_in[116] la_data_in[117] la_data_out[123]
+ la_data_in[112] la_data_out[124] la_data_out[125] la_data_out[126] la_data_out[127]
+ la_data_in[118] la_oenb[109] la_data_in[120] la_oenb[110] la_data_in[121] la_oenb[111]
+ la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117] la_oenb[118]
+ la_oenb[119] la_data_in[122] la_data_in[123] la_oenb[120] la_oenb[121] la_oenb[122]
+ la_oenb[123] la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_data_in[124]
+ la_data_in[125] la_data_in[126] la_data_in[127] la_data_out[110] user_clock2 user_irq[0]
+ la_data_in[113] user_irq[1] la_data_in[114] user_irq[2] la_data_out[111] la_data_out[112]
+ la_data_out[109] la_data_in[109] la_data_out[113] la_data_in[110] la_data_out[114]
+ la_oenb[108] la_data_out[115] la_data_out[116] la_data_in[111] la_data_out[117]
+ la_data_in[115] la_data_out[118] la_data_out[119] io_analog[4] io_analog[5] io_analog[6]
+ gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5] gpio_analog[6] gpio_noesd[2]
+ gpio_noesd[3] gpio_noesd[4] gpio_noesd[5] gpio_noesd[6] io_analog[0] io_analog[1]
+ io_analog[2] io_analog[3] io_clamp_high[0] io_clamp_low[0] io_in[10] io_in[11] io_in[12]
+ io_in[13] io_in[9] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12] io_in_3v3[13] io_in_3v3[9]
+ io_oeb[10] io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[9] io_out[10] io_out[11] io_out[12]
+ io_out[13] io_out[9] vccd1 vdda1 vssa1 io_in[16] io_in[17] gpio_analog[9] gpio_noesd[10]
+ io_analog[7] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_analog[8]
+ io_analog[9] gpio_noesd[7] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] gpio_noesd[8]
+ io_clamp_high[1] io_clamp_high[2] gpio_noesd[9] io_clamp_low[1] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_clamp_low[2] gpio_analog[10] io_analog[10] vccd2 gpio_analog[7]
+ gpio_analog[8] io_in[14] io_in[15] vssa2 io_in_3v3[24] io_in_3v3[25] io_in_3v3[26]
+ gpio_analog[16] gpio_analog[17] gpio_analog[11] gpio_analog[12] gpio_noesd[11] io_in[18]
+ io_in[19] io_in[20] io_in[21] io_oeb[18] io_oeb[19] io_oeb[20] io_oeb[21] io_oeb[22]
+ io_oeb[23] io_oeb[24] io_oeb[25] io_oeb[26] io_in[22] io_in[23] io_in[24] io_in[25]
+ io_in[26] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] io_out[18]
+ io_out[19] io_out[20] io_out[21] io_out[22] io_out[23] io_out[24] io_out[25] io_out[26]
+ gpio_noesd[16] gpio_noesd[17] gpio_analog[13] gpio_analog[14] gpio_analog[15] io_in_3v3[18]
+ io_in_3v3[19] vdda2 io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23] vssd2
+ io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in[1] io_oeb[0] gpio_noesd[0] io_in[2]
+ io_in[3] io_in[4] io_in[5] io_out[1] io_in[6] io_in_3v3[1] io_in[7] io_in[8] gpio_analog[0]
+ io_oeb[1] io_in_3v3[0] io_out[2] io_out[3] io_out[4] io_out[5] io_out[6] io_out[7]
+ io_out[8] gpio_analog[1] gpio_noesd[1] io_in[0] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8] vssd1 io_in_3v3[5]
+ io_out[0]
XTOP_0 VSUBS TOP
.ends
